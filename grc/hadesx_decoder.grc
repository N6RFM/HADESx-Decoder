options:
  parameters:
    comment: IQ -> automatic FSK finder / Doppler tracker -> UNNE-1B 200 bd FSK demod -> deframe -> CRC -> decode. Replace the file source with an SDR source for live use (50 ksps).
    generate_options: qt_gui
    id: hadesx_decoder
    output_language: python
    title: UNNE-1B telemetry decoder (auto-tracking)
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    comment: IQ sample rate (50 ksps)
    value: '50000'
  states: {}
- name: decim
  id: variable
  parameters:
    comment: 50000 / 5 = 10 ksps = 50 samples per symbol
    value: '5'
  states: {}
- name: speed
  id: variable
  parameters:
    comment: File playback speed relative to real time (only used by the throttle)
    value: '4'
  states: {}
- name: min_db
  id: variable
  parameters:
    comment: 'Detection threshold: how far the two FSK tones must stand above the noise floor (dB). Lower = more sensitive.'
    value: '15'
  states: {}
- name: iq_file
  id: variable
  parameters:
    comment: Path to the complex float32 IQ recording
    value: '''examples/iq/pass_t211s_type01.iq'''
  states: {}
- name: dll_path
  id: variable
  parameters:
    comment: 'Optional: path to hadesr.dll for the official field-by-field decode (pip install unicorn pefile)'
    value: ''''''
  states: {}
- name: log_path
  id: variable
  parameters:
    comment: 'Optional: JSON-lines log of decoded frames'
    value: ''''''
  states: {}
- name: c2_path
  id: variable
  parameters:
    comment: 'Optional: file that receives the CODEC2 voice payloads (type 15)'
    value: ''''''
  states: {}
- name: lookahead_s
  id: variable
  parameters:
    comment: Tracker look-ahead delay in seconds; also used to correct the hex-port time stamps
    value: '1.2'
  states: {}
- name: hex_time
  id: variable
  parameters:
    comment: 'Time stamp on the deframer hex port: none, utc, local, unix or stream (docs/gnuradio.md)'
    value: '''none'''
  states: {}
- name: rec_start
  id: variable
  parameters:
    comment: Optional start time of a recording, e.g. 2026-10-04T22:48:12Z, so the stamps follow the file
    value: ''''''
  states: {}
- name: bauds
  id: variable
  parameters:
    comment: 'Baud rates to try: 200, 800 or 200,800 (UNNE-1B sends 200; HADES-SA alternates 800 and 200; HADES-L 800)'
    value: '''200,800'''
  states: {}
- name: emit_unverified
  id: variable
  parameters:
    comment: True = also print length-byte frames whose CRC fails (for exploring new satellites or packet types)
    value: 'False'
  states: {}
- name: out_dir
  id: variable
  parameters:
    comment: Folder to update with one file set per frame type (like the Windows SoundModem/KISSGENESIS tool); empty = off
    value: ''''''
  states: {}
- name: out_history
  id: variable
  parameters:
    comment: 'out_dir: keep one .tlm file per reception as well as the latest one'
    value: 'True'
  states: {}
- name: epy_block_src
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):
          """IQ file source (complex float32) that appends pad_s seconds of silence at the end, so the tracker's
          1.2 s look-ahead delay can flush and the last burst of the file is decoded."""

          def __init__(self, path='', samp_rate=50000.0, pad_s=2.0):
              gr.sync_block.__init__(self, name='IQ file source + end padding', in_sig=None,
                                     out_sig=[np.complex64])
              self.f = open(path, 'rb') if path else None
              self.pad = int(float(pad_s) * float(samp_rate))
              self.eof = False

          def work(self, input_items, output_items):
              out = output_items[0]
              n = len(out)
              got = 0
              if self.f is not None and not self.eof:
                  a = np.fromfile(self.f, dtype=np.complex64, count=n)
                  got = len(a)
                  out[:got] = a
                  if got < n:
                      self.eof = True
              if got < n:
                  if self.pad <= 0:
                      return -1
                  k = min(n - got, self.pad)
                  out[got:got + k] = 0
                  self.pad -= k
                  got += k
                  if got == 0:
                      return -1
              return got
    comment: Reads the IQ file and appends silence at the end. Replace by your SDR source for live use.
    pad_s: '2.0'
    path: iq_file
    samp_rate: samp_rate
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    comment: Only needed for file playback (speed x real time)
    samples_per_second: samp_rate * speed
    type: complex
  states: {}
- name: epy_block_afc
  id: epy_block
  parameters:
    _source_code: |
      # HADESx Decoder  -  https://github.com/N6RFM/HADESx-Decoder
      # Authors: N6RFM, with Claude (an AI assistant made by Anthropic).
      # Licence: MIT (see LICENSE).
      # Built on AMSAT-EA's open documentation and source code (CC BY 4.0): see NOTICE.md. Frame format, scrambler, CRC and the CODEC2
      # voice key come from their documents and decoder. SSDV: the format of Philip Heron's ssdv (NOTICE.md, section 10).
      import time
      import struct
      import re
      from bisect import bisect_left
      from itertools import combinations
      import numpy as np

      # ----------------------------------------------------------------------------
      # UNNE-1B (HADES-E2) FSK telemetry and CODEC2 voice decoder  --  core library
      #
      # This module is deliberately ONE self-contained file (numpy is the only hard
      # dependency) so that tools/build_grc.py can embed it verbatim in the GNU Radio
      # flowgraph.  Sections:
      #   1. protocol constants, CRC, scrambler, voice helpers
      #   2. optional emulation of AMSAT-EA's hadesr.dll (needs unicorn + pefile)
      #   3. FskCentreTracker  - finds / follows the FSK signal anywhere in the band
      #   4. Unne1bDeframer    - demodulator, clock recovery, sync, CRC, bit-error fixing
      #   5. formatting helpers
      #
      # Air interface (AMSAT-EA, "UNNE-1B Descripcion de transmisiones" v1.01):
      #   200 bd 2-FSK, lower tone = mark = 1, bytes MSB first
      #   128-bit 0xAA training, sync 0xBF35, type|address byte, data, CRC16
      #   data is scrambled (x^17 + x^12 + 1, state 0x2C350000, bit 0 of every byte is
      #   skipped - verified against AMSAT-EA's reference genesis_scrambler.c)
      #   CRC-CCITT-FALSE is computed over the *scrambled* bytes (type/addr .. data)
      #
      # Credits: the frame format follows AMSAT-EA's UNNE-1B transmission document; the voice XOR
      # key and padding rule come from AMSAT-EA's HADES-SA_SpinnyONE sources ((c) AMSAT EA, CC BY 4.0);
      # scrambler and CRC behaviour follow AMSAT-EA's genesis_scrambler.c / genesis_crc.c
      # (Gabriel Otero Perez).  Full attribution and the list of changes: NOTICE.md.
      # ----------------------------------------------------------------------------

      __all__ = [
          'SYNC_BITS', 'TOTAL_BYTES', 'PRE_BYTES', 'TYPE_NAMES', 'DLL_FUNCS', 'SOURCES',
          'crc16_ccitt_false', 'ssdv_crc_ok', 'ssdv_plain', 'ssdv_repair', 'rs_ssdv_correct', 'rs_ssdv_parity', 'descramble', 'scramble', 'bits_to_bytes', 'check_frame',
          'VOICE_PAYLOAD_BYTES', 'VOICE_XOR_KEY', 'voice_unwhiten', 'voice_pad_700c', 'voice_assemble',
          'DllDecoder', 'FskCentreTracker', 'Unne1bDeframer', 'MultiBaudDeframer', 'parse_bauds', 'format_frame',
          'type_name', 'check_unne_dll', 'DLL_SATELLITES', 'LEGACY_SOURCES', 'VOICE_TYPES', 'VOICE_SIZE_BYTE', 'SSDV_SIZE_BYTE', 'PN9_SIZES', 'TYPE_NAMES_BY_SOURCE',
      ]

      SYNC_BITS = '1011111100110101'          # 0xBF35

      # total packet size in bytes (training + sync + type/addr + data + crc) per spec
      TOTAL_BYTES = {1: 49, 2: 35, 3: 47, 4: 53, 5: 45, 6: 153, 8: 49, 9: 141,
                     10: 35, 12: 82, 14: 56}
      PRE_BYTES = 18                           # 16 training + 2 sync

      TYPE_NAMES = {1: 'Power', 2: 'Temperature', 3: 'Status', 4: 'Power stats',
                    5: 'Temperature stats', 6: 'Sun sensors', 8: 'Antenna deploy',
                    9: 'Extended power (INA)', 10: 'Nebrija game payload',
                    12: 'Ephemeris', 14: 'Time series', 15: 'CODEC2 voice'}

      DLL_FUNCS = {1: 'visualiza_powerpacket', 2: 'visualiza_temppacket',
                   3: 'visualiza_statuspacket', 4: 'visualiza_powerstatspacket',
                   5: 'visualiza_tempstatspacket', 6: 'visualiza_sunvectorpacket',
                   8: 'visualiza_deploypacket', 9: 'visualiza_ine',
                   10: 'visualiza_nebrijapayload_data_packet',
                   12: 'visualiza_efemeridespacket',
                   14: 'visualiza_time_series_packet'}

      # Source address nibble -> satellite.  UNNE-1B (0xC), MARIA-G (0xB), HADES-ICM (2) are from AMSAT-EA's UNNE-1 /
      # MARIA-G / HADES-R / HADES-ICM document; HADES-SA = 3 is what AMSAT-EA's HADES-SA decoder and its sample frames use.
      # HADES-L: its document gives 5 in the packet tables and 3 in the text - 5 is assumed until real frames settle it.
      SOURCES = {0xC: 'UNNE-1B', 0xB: 'MARIA-G', 2: 'HADES-ICM', 3: 'HADES-SA', 5: 'HADES-L'}

      # Satellites whose frame contents the optional hadesr.dll decodes (UNNE-1, MARIA-G, HADES-R/ICM family).
      DLL_SATELLITES = (0xC, 0xB, 2)
      # Satellites that send the older layout without a length byte (type/addr, data, CRC).
      LEGACY_SOURCES = (0xC, 0xB, 2)

      # Packet type names that differ from the generic TYPE_NAMES above, by source address.
      TYPE_NAMES_BY_SOURCE = {
          3: {7: 'Experiment payload', 8: 'Antenna deploy', 9: 'Extended power (INA)', 10: 'SSDV image packet',
              11: 'CODEC2 voice', 12: 'Ephemeris', 13: 'PN9 link test', 14: 'Time series', 15: 'BBS message'},
          5: {7: 'Lofith payload', 8: 'Antenna deploy', 9: 'Extended power (INA)', 11: 'CODEC2 voice', 12: 'Ephemeris',
              13: 'PN9 link test', 14: 'Time series', 15: 'ICM message'},
      }


      def type_name(src, ptype):
          """Human-readable packet type for a source address."""
          return TYPE_NAMES_BY_SOURCE.get(src, {}).get(ptype) or TYPE_NAMES.get(ptype, '?')


      # CODEC2 voice packet type: 15 on UNNE-1B, 11 on HADES-SA / HADES-L (all carry size 37 = type/addr + number + 35 bytes)
      VOICE_TYPES = (11, 15)
      SSDV_SIZE_BYTE = 251                   # HADES-SA SSDV image packets: type 10, 251 bytes after the size byte
      PN9_SIZES = (249, 255)                 # PN9 link-test packets (HADES-SA 249; the HADES-L document says 255)
      VOICE_SIZE_BYTE = 37


      def _make_crc_table():
          tab = []
          for i in range(256):
              c = i << 8
              for _ in range(8):
                  c = ((c << 1) ^ 0x1021) & 0xFFFF if c & 0x8000 else (c << 1) & 0xFFFF
              tab.append(c)
          return tab


      _CRC_TAB = _make_crc_table()


      def crc16_ccitt_false(data, init=0xFFFF):
          c = init
          for b in data:
              c = ((c << 8) & 0xFFFF) ^ _CRC_TAB[((c >> 8) ^ b) & 0xFF]
          return c


      def ssdv_crc_ok(packet):
          """Check a 256-byte SSDV packet: CRC-32 over bytes 1..219, stored big-endian at 220..223."""
          import zlib
          return len(packet) >= 224 and (zlib.crc32(packet[1:220]) & 0xFFFFFFFF) == int.from_bytes(packet[220:224], 'big')


      def _ssdv_layouts(body):
          """The ways the 251 SSDV bytes (type/address first) might have been scrambled; each gives a candidate."""
          return [body,                                                         # 0: sent as is
                  body[:1] + descramble(body[1:]),                              # 1: everything after type/address scrambled
                  body[:1] + descramble(body[1:215]) + body[215:],              # 2: data scrambled, CRC-32 and FEC as is
                  body[:1] + descramble(body[1:219]) + body[219:],              # 3: data and CRC-32 scrambled, FEC as is
                  body[:1] + descramble(body[1:215]) + body[215:219] + descramble(body[219:])]   # 4: CRC-32 as is, FEC scrambled


      def ssdv_plain(raw):
          """HADES-SA SSDV frame: `raw` = size byte + type/address + 250 bytes (the standard 256-byte SSDV packet is
          55 66 BF 35 FB followed by the 251 bytes after the size byte).  Returns those 251 bytes (type/address first) when
          the packet's own CRC-32 verifies, else None.  Whether the satellite scrambles the SSDV bytes is not settled
          (the spec exempts "training, sync, type and CRC"), so each plausible layout is tried; a CRC-32 pass is proof."""
          body = raw[1:252]
          if len(body) < 251:
              return None
          head = b'\x55\x66\xbf\x35' + raw[0:1]
          good = [cand for cand in _ssdv_layouts(body) if ssdv_crc_ok(head + cand)]
          for cand in good:                       # the CRC-32 does not cover the FEC: prefer the layout whose FEC is consistent
              if rs_ssdv_parity((head + cand)[1:224]) == cand[219:]:
                  return cand
          return good[0] if good else None


      # Reed-Solomon RS(255,223) of the SSDV standard (fsphil/ssdv, libfec decode_rs_8 CCSDS parameters: field polynomial
      # 0x187, first root 112, root step 11, 32 parity bytes, conventional basis).  Verified against the FEC of a real
      # HADES-SA packet.  Corrects up to 16 wrong bytes in the 255 bytes after the 0x55 sync byte.
      _RS_EXP = [0] * 512
      _RS_LOG = [0] * 256
      _x = 1
      for _i in range(255):
          _RS_EXP[_i] = _x
          _RS_LOG[_x] = _i
          _x <<= 1
          if _x & 0x100:
              _x ^= 0x187
      for _i in range(255, 512):
          _RS_EXP[_i] = _RS_EXP[_i - 255]


      def _gmul(a, b):
          return 0 if a == 0 or b == 0 else _RS_EXP[_RS_LOG[a] + _RS_LOG[b]]


      def _gdiv(a, b):
          return 0 if a == 0 else _RS_EXP[(_RS_LOG[a] - _RS_LOG[b]) % 255]


      def rs_ssdv_parity(data223):
          g = [1]
          for i in range(32):
              r = _RS_EXP[(11 * (112 + i)) % 255]
              ng = [0] * (len(g) + 1)
              for j, c in enumerate(g):
                  ng[j] ^= c
                  ng[j + 1] ^= _gmul(c, r)
              g = ng
          par = [0] * 32
          for d in data223:
              fb = d ^ par[0]
              par = par[1:] + [0]
              if fb:
                  for j in range(32):
                      par[j] ^= _gmul(fb, g[j + 1])
          return bytes(par)


      def rs_ssdv_correct(block):
          """block = 255 bytes (data 223 + parity 32).  Returns (corrected 255 bytes, number of bytes fixed) or None."""
          n = 255
          blk = list(block)
          syn = []
          for i in range(32):
              r = _RS_EXP[(11 * (112 + i)) % 255]
              acc = 0
              for c in blk:
                  acc = _gmul(acc, r) ^ c
              syn.append(acc)
          if not any(syn):
              return bytes(blk), 0
          lam, prev, L, m, b = [1], [1], 0, 1, 1                 # Berlekamp-Massey
          for k in range(32):
              d = syn[k]
              for i in range(1, L + 1):
                  if i < len(lam):
                      d ^= _gmul(lam[i], syn[k - i])
              if d == 0:
                  m += 1
                  continue
              t = lam[:]
              coef = _gdiv(d, b)
              shifted = [0] * m + [_gmul(coef, c) for c in prev]
              lam = lam + [0] * (len(shifted) - len(lam))
              for i, c in enumerate(shifted):
                  lam[i] ^= c
              if 2 * L <= k:
                  L, prev, b, m = k + 1 - L, t, d, 1
              else:
                  m += 1
          if L > 16:
              return None
          lam = lam[:L + 1] + [0] * max(0, L + 1 - len(lam))
          pos = []
          for idx in range(n):                                   # error at index idx has locator X = alpha^(11 * (254 - idx))
              xinv = _RS_EXP[(-11 * (254 - idx)) % 255]
              v, pw = 0, 1
              for c in lam:
                  v ^= _gmul(c, pw)
                  pw = _gmul(pw, xinv)
              if v == 0:
                  pos.append(idx)
          if len(pos) != L:
              return None
          omega = [0] * 32                                       # Omega = S(x) * Lambda(x) mod x^32
          for i in range(32):
              acc = 0
              for j in range(min(i, L) + 1):
                  acc ^= _gmul(lam[j], syn[i - j])
              omega[i] = acc
          for idx in pos:
              x = _RS_EXP[(11 * (254 - idx)) % 255]
              xinv = _RS_EXP[(-11 * (254 - idx)) % 255]
              num, pw = 0, 1
              for c in omega:
                  num ^= _gmul(c, pw)
                  pw = _gmul(pw, xinv)
              den, pw = 0, 1                                     # Lambda'(xinv): odd terms only
              for j in range(1, len(lam), 2):
                  den ^= _gmul(lam[j], _RS_EXP[(_RS_LOG[xinv] * (j - 1)) % 255] if xinv else 0)
              if den == 0:
                  return None
              # magnitude = X^(1 - fcr) * Omega(Xinv) / Lambda'(Xinv), fcr = 112
              mag = _gmul(_gdiv(num, den), _RS_EXP[((1 - 112) * _RS_LOG[x]) % 255])
              blk[idx] ^= mag
          again = rs_ssdv_parity(bytes(blk[:223]))
          if again != bytes(blk[223:]):
              return None
          return bytes(blk), len(pos)


      def ssdv_repair(raw):
          """Like ssdv_plain(), but lets the Reed-Solomon code repair damaged bytes first.  Returns
          (251 plain bytes, number of bytes repaired) or None.  The result is accepted only if its CRC-32 then verifies."""
          body = raw[1:252]
          if len(body) < 251:
              return None
          head = b'\x55\x66\xbf\x35' + raw[0:1]
          for cand in _ssdv_layouts(body):
              packet = head + cand
              fixed = rs_ssdv_correct(packet[1:])
              if fixed is not None and ssdv_crc_ok(b'\x55' + fixed[0]):
                  return fixed[0][4:], fixed[1]
          return None


      def descramble(data, init=0x2C350000):
          """Self-synchronising descrambler.  Behaviour defined by AMSAT-EA's genesis_scrambler.c
          (Gabriel Otero Perez, (c) AMSAT EA, CC BY 4.0, github.com/AMSAT-EA/HADES-SA_SpinnyONE);
          this is an independent Python implementation, checked against that C code."""
          reg = init
          out = bytearray(data)
          for k in range(len(out)):
              b = out[k]
              for i in range(7, 0, -1):            # bits 7..1 (bit 0 is left alone)
                  inb = (b >> i) & 1
                  fb = ((reg >> 16) & 1) ^ inb ^ ((reg >> 11) & 1)
                  if fb:
                      b |= (1 << i)
                  else:
                      b &= ~(1 << i)
                  reg = ((reg << 1) | inb) & 0x1FFFF
              out[k] = b
          return bytes(out)


      def bits_to_bytes(bits):
          n = len(bits) // 8 * 8
          return bytes(int(''.join(map(str, bits[i:i + 8])), 2) for i in range(0, n, 8))


      def check_frame(raw):
          """raw = bytes after sync (type/addr .. data .. crc). Returns (ok, plain)."""
          body = raw[:-2]
          rx = (raw[-2] << 8) | raw[-1]
          ok = crc16_ccitt_false(body) == rx
          plain = raw[:1] + descramble(raw[1:-2])
          return ok, plain


      def scramble(data, init=0x2C350000):
          """Inverse of descramble() (what the satellite does before transmitting)."""
          reg = init
          out = bytearray(data)
          for k in range(len(out)):
              b = out[k]
              for i in range(7, 0, -1):
                  inb = (b >> i) & 1
                  o = inb ^ ((reg >> 16) & 1) ^ ((reg >> 11) & 1)
                  if o:
                      b |= (1 << i)
                  else:
                      b &= ~(1 << i)
                  reg = ((reg << 1) | o) & 0x1FFFF
              out[k] = b
          return bytes(out)


      # ---- CODEC2 voice (type 15) helpers ---------------------------------------
      # Each voice packet: sync(2) | size=0x25 | 0xF<<4|addr | frame number | 35 payload bytes
      # The 35 bytes are XOR-whitened with a fixed keystream and hold ten 28-bit Codec2 700C frames.
      # Attribution: the key values below are copied unchanged from AMSAT-EA's HADES-SA_SpinnyONE
      # repository, byte_version/main.c (visualiza_codec2, xor_codec2[35]), (c) AMSAT EA 2026,
      # licensed CC BY 4.0 (https://creativecommons.org/licenses/by/4.0/); the 28-bit -> 4-byte
      # padding rule is re-implemented from add_padding_codec2() in the same file.
      VOICE_PAYLOAD_BYTES = 35
      VOICE_XOR_KEY = bytes([
          0xed, 0x15, 0xd5, 0x3b, 0x34, 0x70, 0xe0, 0xfd, 0xed, 0x83, 0x90, 0xdb,
          0xaa, 0x2e, 0x25, 0xd6, 0x5e, 0x81, 0x41, 0x86, 0xbd, 0x67, 0x79, 0x5d,
          0x70, 0xa1, 0x13, 0xce, 0x50, 0x0c, 0x19, 0xca, 0xfb, 0x44, 0x0d])
      C2_700C_FRAME_BITS = 28
      C2_700C_FRAMES_PER_PACKET = 10


      def voice_unwhiten(payload):
          """Remove the fixed XOR keystream from a 35-byte voice payload."""
          return bytes(a ^ b for a, b in zip(payload, VOICE_XOR_KEY))


      def voice_pad_700c(payload_unwhitened):
          """35 bytes -> 10 frames x 4 bytes (28 bits + 4 zero bits), the layout c2dec reads."""
          bits = np.unpackbits(np.frombuffer(payload_unwhitened, dtype=np.uint8))
          out = bytearray()
          for k in range(C2_700C_FRAMES_PER_PACKET):
              fb = np.zeros(32, dtype=np.uint8)
              fb[:C2_700C_FRAME_BITS] = bits[k * C2_700C_FRAME_BITS:(k + 1) * C2_700C_FRAME_BITS]
              out += np.packbits(fb).tobytes()
          return bytes(out)


      def voice_assemble(packets):
          """packets: {frame_number: 35 whitened bytes}.  Returns (c2dec input bytes, missing numbers).
          Missing packets become 40 zero bytes (10 silent frames), like AMSAT-EA's merge tool."""
          if not packets:
              return b'', []
          first, last = min(packets), max(packets)
          out, missing = bytearray(), []
          for n in range(first, last + 1):
              if n in packets:
                  out += voice_pad_700c(voice_unwhiten(packets[n]))
              else:
                  out += bytes(4 * C2_700C_FRAMES_PER_PACKET)
                  missing.append(n)
          return bytes(out), missing


      # ----------------------------------------------------------------------------
      # Optional: use the real hadesr.dll (AMSAT-EA) inside an x86 emulator so that the
      # official text decoder can be used on Linux without Wine.  Needs: unicorn, pefile
      # ----------------------------------------------------------------------------
      def check_unne_dll(path, export_names):
          """--dll takes hadesr.dll, the decoder of the UNNE-1B package. The HADES-SA and HADES-L packages have DLLs with the same style of
          names but different functions: refuse them with a clear message instead of printing nonsense."""
          names = set(export_names)
          if 'visualiza_nebrijapayload_data_packet' in names:
              return
          base = path.replace('\\', '/').split('/')[-1]
          if 'visualiza_lofith' in names:
              what = "%s is the HADES-L package's decoder" % base
          elif 'visualiza_ssdv' in names:
              what = "%s is the HADES-SA package's decoder" % base
          else:
              what = '%s is not the UNNE-1B package\'s hadesr.dll' % base
          raise ValueError('%s. --dll takes hadesr.dll from the UNNE-1B package; HADES-SA and HADES-L need no DLL (this program decodes '
                           'them itself).' % what)


      class DllDecoder:
          def __init__(self, path):
              import pefile
              from unicorn import Uc, UC_ARCH_X86, UC_MODE_32, UC_HOOK_CODE
              from unicorn.x86_const import (UC_X86_REG_ESP, UC_X86_REG_EIP,
                                             UC_X86_REG_EAX)
              self._u = (UC_X86_REG_ESP, UC_X86_REG_EIP, UC_X86_REG_EAX)
              pe = pefile.PE(path)
              base = pe.OPTIONAL_HEADER.ImageBase
              mu = Uc(UC_ARCH_X86, UC_MODE_32)
              size = (pe.OPTIONAL_HEADER.SizeOfImage + 0xFFF) & ~0xFFF
              mu.mem_map(base, size)
              mu.mem_write(base, pe.header)
              for s in pe.sections:
                  mu.mem_write(base + s.VirtualAddress, s.get_data())
              self.exp = {e.name.decode(): base + e.address
                          for e in pe.DIRECTORY_ENTRY_EXPORT.symbols if e.name}
              check_unne_dll(path, self.exp)
              self.FAKE = 0x10000000
              mu.mem_map(self.FAKE, 0x10000)
              self.imp = {}
              n = 0
              for ent in pe.DIRECTORY_ENTRY_IMPORT:
                  for i in ent.imports:
                      addr = self.FAKE + n * 16
                      n += 1
                      mu.mem_write(i.address, struct.pack('<I', addr))
                      mu.mem_write(addr, b'\xc3')
                      self.imp[addr] = i.name.decode() if i.name else str(i.ordinal)
              self.STACK = 0x7000000
              mu.mem_map(self.STACK, 0x200000)
              self.HEAP = 0x8000000
              mu.mem_map(self.HEAP, 0x400000)
              self.mu = mu
              self.out = []
              mu.hook_add(UC_HOOK_CODE, self._hook, begin=self.FAKE, end=self.FAKE + 0x10000)

          def _rd(self, a, n):
              return bytes(self.mu.mem_read(a, n))

          def _cstr(self, a):
              s = b''
              while True:
                  c = self._rd(a, 1)
                  if c == b'\0':
                      return s
                  s += c
                  a += 1

          def _arg(self, k):
              esp = self.mu.reg_read(self._u[0])
              return struct.unpack('<I', self._rd(esp + 4 + 4 * k, 4))[0]

          def _cfmt(self, fmt, k):
              res = b''
              pos = 0
              pat = re.compile(rb'%([-+ #0]*)(\d*)(?:\.(\d+))?(l|h|ll)?([diuxXcsfeEgG%])')
              for m in pat.finditer(fmt):
                  res += fmt[pos:m.start()]
                  pos = m.end()
                  flags, w, pr, _l, conv = m.groups()
                  if conv == b'%':
                      res += b'%'
                      continue
                  f = '%' + (flags or b'').decode() + (w or b'').decode() + \
                      ('.' + pr.decode() if pr else '')
                  if conv in b'feEgG':
                      lo, hi = self._arg(k), self._arg(k + 1)
                      k += 2
                      v = struct.unpack('<d', struct.pack('<II', lo, hi))[0]
                      res += ((f + conv.decode()) % v).encode()
                      continue
                  v = self._arg(k)
                  k += 1
                  if conv == b's':
                      res += self._cstr(v)
                  elif conv == b'c':
                      res += bytes([v & 255])
                  else:
                      if conv in b'di' and v >= 2 ** 31:
                          v -= 2 ** 32
                      res += ((f + conv.decode().replace('i', 'd')) % v).encode()
              return res + fmt[pos:]

          @staticmethod
          def _tm(t, gm):
              s = time.gmtime(t) if gm else time.localtime(t)
              return struct.pack('<9I', s.tm_sec, s.tm_min, s.tm_hour, s.tm_mday,
                                 s.tm_mon - 1, s.tm_year - 1900,
                                 (s.tm_wday + 1) % 7, s.tm_yday - 1, max(s.tm_isdst, 0))

          def _hook(self, mu, addr, sz, ud):
              if addr not in self.imp:
                  return
              name = self.imp[addr].lstrip('_')
              esp = mu.reg_read(self._u[0])
              ret = 0
              if name in ('time', 'time64', 'time32'):
                  ret = int(time.time())
                  t = self._arg(0)
                  if t:
                      mu.mem_write(t, struct.pack('<I', ret))
              elif name in ('localtime', 'localtime64', 'localtime32', 'gmtime',
                            'gmtime64', 'gmtime32'):
                  tp = self._arg(0)
                  t = struct.unpack('<i', self._rd(tp, 4))[0]
                  try:
                      blob = self._tm(t, name.startswith('gm'))
                      ret = self.HEAP + 0x100
                      mu.mem_write(ret, blob)
                  except (OverflowError, OSError, ValueError):
                      ret = 0
              elif name == 'sprintf':
                  s = self._cfmt(self._cstr(self._arg(1)), 2)
                  mu.mem_write(self._arg(0), s + b'\0')
                  ret = len(s)
              elif name == 'printf':
                  s = self._cfmt(self._cstr(self._arg(0)), 1)
                  self.out.append(s.decode('latin1'))
                  ret = len(s)
              elif name == 'puts':
                  self.out.append(self._cstr(self._arg(0)).decode('latin1') + '\n')
              elif name == 'putchar':
                  self.out.append(chr(self._arg(0) & 255))
              elif name in ('fflush', 'setvbuf'):
                  ret = 0
              elif name == 'fprintf':                      # fprintf(stream, format, ...): every stream goes to the captured text
                  s = self._cfmt(self._cstr(self._arg(1)), 2)
                  self.out.append(s.decode('latin1'))
                  ret = len(s)
              elif name == 'fputs':                        # fputs(string, stream)
                  self.out.append(self._cstr(self._arg(0)).decode('latin1'))
                  ret = 1
              elif name in ('fputc', 'putc'):              # fputc(char, stream)
                  ret = self._arg(0) & 255
                  self.out.append(chr(ret))
              elif name == 'fwrite':                       # fwrite(buffer, size, count, stream)
                  n = min(self._arg(1) * self._arg(2), 65536)
                  self.out.append(self._rd(self._arg(0), n).decode('latin1'))
                  ret = self._arg(2)
              elif name in ('iob_func', 'acrt_iob_func'):  # the stdout/stderr handles: only ever handed back to fprintf and friends
                  ret = self.HEAP + 0x300
              else:
                  self.out.append('[hadesr.dll import "%s" not emulated]\n' % name)
              mu.reg_write(self._u[2], ret & 0xFFFFFFFF)
              retaddr = struct.unpack('<I', self._rd(esp, 4))[0]
              mu.reg_write(self._u[0], esp + 4)
              mu.reg_write(self._u[1], retaddr)

          def decode(self, ptype, src, plain):
              func = DLL_FUNCS.get(ptype)
              if func is None or func not in self.exp:
                  return None
              from unicorn import UcError
              self.out = []
              buf = self.HEAP + 0x200000
              self.mu.mem_write(buf, b'\xaa' * 16 + b'\xbf\x35' + plain + b'\0' * 512)
              esp = self.STACK + 0x1F0000
              for a in (buf, src):                 # cdecl: push right-to-left
                  esp -= 4
                  self.mu.mem_write(esp, struct.pack('<I', a))
              esp -= 4
              self.mu.mem_write(esp, struct.pack('<I', 0xDEAD0000))
              self.mu.reg_write(self._u[0], esp)
              try:
                  self.mu.emu_start(self.exp[func], 0xDEAD0000)
              except UcError as e:
                  self.out.append('[emulation stopped: %s]\n' % e)
              return ''.join(self.out)



      # ----------------------------------------------------------------------------
      # Adaptive FSK centre tracker / channelizer ("AFC")
      #   Looks ahead by `delay_s` seconds: it analyses the incoming wideband IQ for the
      #   two-tone signature of the UNNE-1B FSK signal anywhere in the band, estimates the
      #   centre of the two tones every 0.1 s (also following Doppler drift inside a burst),
      #   and mixes the delayed stream so that the centre sits at 0 Hz.  Because of the
      #   look-ahead the mixer is already on the right frequency when a burst begins, even if
      #   the Doppler shift moved by several kHz since the previous burst.
      # ----------------------------------------------------------------------------
      class FskCentreTracker(object):
          def __init__(self, fs=50000.0, delay_s=1.2, nfft=8192, hop_s=0.1, min_db=15.0,
                       spacing=(1000.0, 2400.0), persist=3, spread=250.0, window_s=0.35,
                       lead_s=0.6):
              self.fs = float(fs)
              self.nfft = int(nfft)
              self.hop = max(1, int(round(hop_s * fs)))
              self.delay = int(round(delay_s * fs))
              if self.delay < 2 * self.nfft:
                  raise ValueError('delay too short for the FFT size')
              self.min_lin = 10.0 ** (min_db / 10.0)
              self.spacing = spacing
              self.persist = int(persist)
              self.spread = float(spread)
              self.win_n = int(window_s * fs)
              self.lead_n = int(lead_s * fs)
              self.freqs = np.fft.fftshift(np.fft.fftfreq(self.nfft, 1.0 / self.fs))
              self.win = np.hanning(self.nfft)
              self.buf = np.zeros(0, dtype=np.complex64)
              self.n_in = 0                       # total input samples
              self.out_pos = 0                    # next output sample index (global)
              self.next_hop = 0
              self.raw = {}                       # hop -> (tag, centre, spacing, dB)
              self.acc_tags = []                  # accepted detections, sorted by tag
              self.acc_cent = []
              self.acc_hops = set()
              self.phase = 0.0
              self.last_c = 0.0
              self.cache = {}

          # -- detection -----------------------------------------------------------
          def _detect(self, seg):
              P = np.abs(np.fft.fftshift(np.fft.fft(seg * self.win))) ** 2
              floor = float(np.median(P)) + 1e-30
              Ps = np.convolve(P, np.ones(3) / 3.0, 'same')
              mx = np.where((Ps[1:-1] > Ps[:-2]) & (Ps[1:-1] >= Ps[2:]))[0] + 1
              mx = mx[Ps[mx] > floor * self.min_lin]
              if len(mx) < 2:
                  return None
              order = mx[np.argsort(Ps[mx])[::-1]][:12]
              best = None
              for i, p1 in enumerate(order):
                  for p2 in order[i + 1:]:
                      d = abs(self.freqs[p1] - self.freqs[p2])
                      if self.spacing[0] <= d <= self.spacing[1]:
                          lo, hi = (p1, p2) if self.freqs[p1] < self.freqs[p2] else (p2, p1)
                          score = min(Ps[lo], Ps[hi])
                          if min(Ps[lo], Ps[hi]) >= 0.1 * max(Ps[lo], Ps[hi]) and \
                                  (best is None or score > best[0]):
                              best = (score, lo, hi)
              if best is None:
                  return None
              _, lo, hi = best

              def refine(k):
                  y0, y1, y2 = np.log(Ps[k - 1] + 1e-30), np.log(Ps[k] + 1e-30), np.log(Ps[k + 1] + 1e-30)
                  den = y0 - 2 * y1 + y2
                  off = 0.5 * (y0 - y2) / den if den != 0 else 0.0
                  return self.freqs[k] + max(-1.0, min(1.0, off)) * (self.fs / self.nfft)
              f_lo, f_hi = refine(lo), refine(hi)
              return ((f_lo + f_hi) / 2.0, f_hi - f_lo,
                      10.0 * np.log10(min(Ps[lo], Ps[hi]) / floor))

          def _analyse(self):
              while self.next_hop * self.hop + self.nfft <= self.n_in:
                  h = self.next_hop
                  a = h * self.hop - self.out_base
                  if a < 0:
                      self.next_hop += 1
                      continue
                  det = self._detect(self.buf[a:a + self.nfft])
                  self.next_hop += 1
                  if det is not None:
                      self.raw[h] = (h * self.hop + self.nfft // 2,) + det
                      self._persist(h)
                  self.raw.pop(h - 50, None)

          def _persist(self, h):
              hs = [h - k for k in range(self.persist)]
              if not all(x in self.raw for x in hs):
                  return
              cs = [self.raw[x][1] for x in hs]
              if max(cs) - min(cs) > self.spread:
                  return
              for x in sorted(hs):
                  if x not in self.acc_hops:
                      self.acc_hops.add(x)
                      tag, c = self.raw[x][0], self.raw[x][1]
                      i = len(self.acc_tags)
                      while i > 0 and self.acc_tags[i - 1] > tag:
                          i -= 1
                      self.acc_tags.insert(i, tag)
                      self.acc_cent.insert(i, c)

          # -- centre as a function of time ---------------------------------------
          def _centre_for_block(self, blk):
              if blk in self.cache:
                  return self.cache[blk]
              tmid = (blk + 0.5) * self.hop
              tags = np.asarray(self.acc_tags)
              cents = np.asarray(self.acc_cent)
              c = None
              if len(tags):
                  near = np.abs(tags - tmid) <= self.win_n
                  if near.any():
                      c = float(np.median(cents[near]))
                  else:
                      fut = np.where((tags > tmid) & (tags <= tmid + self.lead_n))[0]
                      if len(fut):
                          c = float(cents[fut[0]])
                      else:
                          past = np.where(tags < tmid)[0]
                          if len(past):
                              c = float(cents[past[-1]])
              if c is None:
                  c = self.last_c
              self.last_c = c
              self.cache[blk] = c
              for k in [k for k in self.cache if k < blk - 4]:
                  del self.cache[k]
              return c

          # -- streaming interface -------------------------------------------------
          @property
          def out_base(self):
              return self._out_base

          _out_base = 0

          def push(self, x, flush=False):
              x = np.asarray(x, dtype=np.complex64)
              self.buf = np.concatenate([self.buf, x])
              self.n_in += len(x)
              self._analyse()
              end = self.n_in if flush else self.n_in - self.delay
              if end <= self.out_pos:
                  return np.zeros(0, np.complex64), np.zeros(0, np.float32)
              ys, cs = [], []
              pos = self.out_pos
              while pos < end:
                  blk = pos // self.hop
                  seg_end = min(end, (blk + 1) * self.hop)
                  c = self._centre_for_block(blk)
                  seg = self.buf[pos - self._out_base:seg_end - self._out_base]
                  k = np.arange(len(seg))
                  ph = self.phase + 2.0 * np.pi * c / self.fs * k
                  ys.append((seg * np.exp(-1j * ph)).astype(np.complex64))
                  cs.append(np.full(len(seg), c, np.float32))
                  self.phase = (self.phase + 2.0 * np.pi * c / self.fs * len(seg)) % (2 * np.pi)
                  pos = seg_end
              self.out_pos = pos
              drop = self.out_pos - self._out_base
              if drop > 0:
                  self.buf = self.buf[drop:]
                  self._out_base += drop
              return np.concatenate(ys), np.concatenate(cs)

          def flush(self):
              return self.push(np.zeros(0, np.complex64), flush=True)


      # ----------------------------------------------------------------------------
      # Streaming demodulator / deframer
      # ----------------------------------------------------------------------------
      class Unne1bDeframer(object):
          """Feed it complex baseband centred on the FSK signal (|offset| < ~1.5 kHz)
          and band-limited to about +-2 kHz, sample rate fs (e.g. 10 kHz)."""

          def __init__(self, fs=10000.0, baud=200.0, kp=0.15, ki=0.002,
                       max_flips=3, flip_candidates=16, clip_hz=2500.0, emit_unverified=False):
              self.fs = float(fs)
              self.baud = float(baud)
              self.emit_unverified = bool(emit_unverified)
              self.sps0 = self.fs / float(baud)
              self.T = self.sps0
              self.kp, self.ki = kp, ki
              self.max_flips, self.flip_candidates = max_flips, flip_candidates
              self.clip = clip_hz
              self.last = 1 + 0j
              self.ma_len = max(8, int(round(24 * self.sps0)))
              self.sm_len = max(1, int(round(self.sps0 / 6.0)))
              self.tail_ma = np.zeros(0)
              self.tail_sm = np.zeros(0)
              self.tail_fa = np.zeros(0)
              self.prev_dd = 0.0
              self.n = 0                         # samples consumed so far
              self.buf = np.zeros(0, dtype=np.float32)
              self.xbuf = np.zeros(0, dtype=np.complex64)   # complex baseband, same indexing
              self.fbuf = np.zeros(0, dtype=np.float32)     # smoothed absolute frequency (Hz)
              self.buf0 = 0                      # global index of buf[0]
              self.fm = None                     # tracked mark   (lower tone) frequency, Hz
              self.fs_ = None                    # tracked space  (higher tone) frequency, Hz
              self.nf = None                     # running noise-floor estimate (|x|^2 per sample)
              self.nf_min = float('inf')         # lowest noise floor seen
              self.nseed = []                    # first noise-power samples used to seed nf
              self.fm0 = self.fs0 = None         # first learned tone frequencies (for clamping)
              self.nafc = 0                      # confident symbols seen (AFC gain schedule)
              self.lm, self.ls, self.nlearn = [], [], 0   # tone-learning scratch
              self.span = 450.0                  # tone search half-width, Hz
              self.fstep = 25.0
              self.edges = []
              self.t = None
              self.quiet = 99                    # symbols since the signal was last strong (burst-start detection)
              self.alt = 0                       # length of the current run of alternating bits (training pattern)
              self.T_ref = self.sps0             # symbol period learned from the last training pattern
              self.bits = []
              self.soft = []
              self.scan = 0
              self.nframes = 0
              self.dropped = 0                   # bits trimmed from the front of self.bits so far
              self.failed = set()                # (global sync position, layout) already tried and rejected

          @staticmethod
          def _causal_ma(x, L, tail):
              hist = np.concatenate([tail, x]).astype(np.float64)
              cs = np.cumsum(hist)
              p = np.arange(len(tail), len(hist))
              s = np.maximum(p - L + 1, 0)
              prev = np.where(s > 0, cs[np.maximum(s - 1, 0)], 0.0)
              y = (cs[p] - prev) / (p - s + 1)
              new_tail = hist[-(L - 1):] if L > 1 else np.zeros(0)
              return y, new_tail

          def push(self, x):
              """x: complex samples. Returns (demod_float32_same_length, [frames])."""
              x = np.asarray(x, dtype=np.complex64)
              if len(x) == 0:
                  return np.zeros(0, np.float32), []
              xx = np.concatenate([[self.last], x])
              disc = np.angle(xx[1:] * np.conj(xx[:-1])) * self.fs / (2 * np.pi)
              self.last = x[-1]
              disc = np.clip(disc, -self.clip, self.clip)
              mean, self.tail_ma = self._causal_ma(disc, self.ma_len, self.tail_ma)
              dd, self.tail_sm = self._causal_ma(disc - mean, self.sm_len, self.tail_sm)
              dd32 = dd.astype(np.float32)
              fabs, self.tail_fa = self._causal_ma(disc, self.sm_len, self.tail_fa)

              # zero crossings (sub-sample)
              s = np.concatenate([[self.prev_dd], dd])
              idx = np.where(np.signbit(s[:-1]) != np.signbit(s[1:]))[0]
              if len(idx):
                  frac = -s[idx] / (s[idx + 1] - s[idx])
                  self.edges.extend((self.n - 1 + idx + frac).tolist())
              self.prev_dd = float(dd[-1])
              self.n += len(x)
              self.buf = np.concatenate([self.buf, dd32])
              self.xbuf = np.concatenate([self.xbuf, x])
              self.fbuf = np.concatenate([self.fbuf, fabs.astype(np.float32)])

              self._dpll()
              frames = self._scan_frames()
              return dd32, frames

          def _decide(self, t, T, a, b, m, p, strong):
              """Per-symbol decision. Non-coherent tone-energy detector (about 10 dB better than
              the FM discriminator near the noise floor) once both tones have been learned."""
              a0 = int(round(t - T / 2)) - self.buf0
              b0 = a0 + int(round(T))
              hard = 1 if m < 0 else 0
              if self.fm is None or self.fs_ is None:
                  if strong and abs(m) > 300.0:
                      self.nlearn += 1
                      if self.nlearn > 4:                     # skip the burst-onset transient
                          q = max(1, (b - a) // 4)
                          fa = float(self.fbuf[a + q:b - q].mean())   # middle half: avoids transitions
                          (self.lm if hard else self.ls).append(fa)
                          if len(self.lm) >= 6 and len(self.ls) >= 6:
                              fm = float(np.median(self.lm[-8:]))
                              fs_ = float(np.median(self.ls[-8:]))
                              if fs_ - fm >= 600.0:
                                  self.fm, self.fs_ = fm, fs_
                                  self.fm0, self.fs0 = fm, fs_
                              else:                           # implausible: start over
                                  self.lm, self.ls, self.nlearn = [], [], 0
                  return hard, -m
              if a0 < 0 or b0 > len(self.xbuf):
                  return hard, -m
              seg = self.xbuf[a0:b0]
              k = np.arange(len(seg))
              grid = np.arange(-self.span, self.span + 1, self.fstep)

              def best(fc):
                  fr = fc + grid
                  E = np.abs(np.exp(-2j * np.pi * np.outer(fr, k) / self.fs) @ seg) ** 2
                  i = int(np.argmax(E))
                  return E[i], fr[i]
              em, fm_new = best(self.fm)
              es, fs_new = best(self.fs_)
              z = (em - es) / (em + es + 1e-20)             # >0 -> mark (bit 1)
              bit = 1 if z > 0 else 0
              if strong and abs(z) > 0.5:                   # AFC, only on confident, strong symbols
                  g = 0.3 if self.nafc < 40 else 0.1         # converge fast, then track slowly
                  self.nafc += 1
                  if bit:
                      self.fm = float(np.clip((1 - g) * self.fm + g * fm_new,
                                              self.fm0 - 700, self.fm0 + 700))
                  else:
                      self.fs_ = float(np.clip((1 - g) * self.fs_ + g * fs_new,
                                               self.fs0 - 700, self.fs0 + 700))
              return bit, z * 1000.0

          def _dpll(self):
              if self.t is None:
                  self.t = self.buf0 + self.T
              T, t = self.T, self.t
              lo, hi = self.sps0 * 0.97, self.sps0 * 1.03
              end = self.buf0 + len(self.buf)
              while t + 0.75 * T + 2 < end:
                  a = int(t - T / 4) - self.buf0
                  b = int(t + T / 4) - self.buf0 + 1
                  if a < 0:                     # data already trimmed: resync
                      t = self.buf0 + T
                      continue
                  m = float(self.buf[a:b].mean())
                  xa = int(round(t - T / 2)) - self.buf0
                  xb = xa + int(round(T))
                  if xa >= 0 and xb <= len(self.xbuf):
                      p = float(np.mean(np.abs(self.xbuf[xa:xb]) ** 2))
                  else:
                      p = 0.0
                  if p > 1e-14:                          # ignore the silent (zero) pre-fill of the tracker
                      if self.nf is None:
                          self.nseed.append(p)
                          if len(self.nseed) >= 40:      # seed the noise floor robustly
                              self.nf = 0.7 * float(np.median(self.nseed))
                              self.nf_min = self.nf
                      elif p < self.nf:
                          self.nf = p
                          self.nf_min = min(self.nf_min, p)
                      else:                              # rises only slowly, but never far above the lowest floor seen (a long continuous burst must stay "strong")
                          self.nf = min(self.nf * 1.0015, 50.0 * self.nf_min)
                  strong = self.nf is not None and p > 6.0 * self.nf
                  if strong:
                      if self.quiet >= 24:             # a new burst: the bit rate is the nominal one again
                          T = self.T_ref = self.sps0
                      self.quiet = 0
                  else:
                      self.quiet += 1
                  bit, soft = self._decide(t, T, a, b, m, p, strong)
                  self.alt = self.alt + 1 if self.bits and bit != self.bits[-1] else 0
                  self.bits.append(bit)
                  self.soft.append(soft)
                  tb = t + T / 2
                  j = bisect_left(self.edges, tb - T / 2)       # +-T/2 capture range: no dead zone
                  if strong and j < len(self.edges) and self.edges[j] < tb + T / 2:
                      err = self.edges[j] - tb
                      t += self.kp * err
                      if self.alt >= 8:        # the rate is learned from the training pattern at a high gain ...
                          T = min(hi, max(lo, T + 5.0 * self.ki * err))
                          self.T_ref = T
                      else:                    # ... and from the data only gently and within +-0.5 % of that (unscrambled data biases the edges)
                          r = self.T_ref
                          T = min(r * 1.005, max(r * 0.995, T + 0.25 * self.ki * err))
                  t += T
              self.T, self.t = T, t
              # trim buffers
              keep_from = int(t - 2 * T)
              drop = keep_from - self.buf0
              if drop > 0:
                  self.buf = self.buf[drop:]
                  self.xbuf = self.xbuf[drop:]
                  self.fbuf = self.fbuf[drop:]
                  self.buf0 += drop
              k = bisect_left(self.edges, keep_from)
              if k:
                  del self.edges[:k]

          @staticmethod
          def _checker(kind, crc_from):
              """Returns (check(raw) -> bool, plain_of(raw)) for a layout.  `raw` = the bytes after the sync word."""
              if kind == 'ssdv':                                   # HADES-SA image packet: no CRC16, SSDV's own CRC32
                  def plain_of(raw):
                      return ssdv_plain(raw) or raw[1:]            # unverified: leave as received

                  def check(raw):
                      return ssdv_plain(raw) is not None
                  return check, plain_of

              def check(raw):
                  return crc16_ccitt_false(raw[crc_from:-2]) == (raw[-2] << 8 | raw[-1])

              def plain_of(raw):
                  return raw[crc_from:crc_from + 1] + descramble(raw[crc_from + 1:-2])
              return check, plain_of

          @classmethod
          def _attempt(cls, rawbits, softs, crc_from, nflips, flip_candidates, kind='crc16'):
              """Try to make the frame pass its check by flipping exactly `nflips` of the least certain bits (0 = as
              received).  Returns (plain, raw, flips) on success, else None.  `plain` = type/address byte + descrambled data."""
              check, plain_of = cls._checker(kind, crc_from)
              if nflips == 0:
                  raw = bits_to_bytes(rawbits)
                  return (plain_of(raw), raw, []) if check(raw) else None
              lo = 8 * (crc_from + 1)
              sv = np.abs(np.array(softs[lo:]))
              order = (np.argsort(sv)[:flip_candidates] + lo).tolist()
              for comb in combinations(order, nflips):
                  bb = list(rawbits)
                  for c in comb:
                      bb[c] ^= 1
                  r2 = bits_to_bytes(bb)
                  if check(r2):
                      return plain_of(r2), r2, list(comb)
              return None

          @staticmethod
          def _has_sclock(src, ptype):
              if src in (3, 5):                                   # HADES-SA / HADES-L
                  return ptype in ((1, 2, 3, 4, 5, 14, 15) if src == 5 else (1, 2, 3, 4, 5, 14))
              return ptype in (1, 2, 3, 4, 5, 10, 14)             # UNNE-1B family

          def _frame_dict(self, framing, plain, raw, flips, crc_ok):
              ptype, src = plain[0] >> 4, plain[0] & 0x0F
              fr = {'type': ptype, 'src': src, 'src_name': SOURCES.get(src, 'unknown'),
                    'type_name': type_name(src, ptype), 'framing': framing, 'baud': int(self.baud),
                    'raw': raw.hex(), 'plain': plain.hex(), 'flips': flips, 'crc_ok': crc_ok,
                    'sclock': (struct.unpack('<I', plain[1:5])[0] if self._has_sclock(src, ptype) and len(plain) >= 5 else
                               (struct.unpack('<I', plain[2:6])[0] if (src, ptype) == (5, 7) and len(plain) >= 6 else None))}
              if framing == 'sized':
                  fr['size'] = raw[0]
              return fr

          def _byte_at(self, i):
              return int(''.join(map(str, self.bits[i:i + 8])), 2)

          def _scan_frames(self):
              """Find frames after each 0xBF35 sync word.  Three layouts are recognised:
                legacy   type/addr, data, CRC                    (UNNE-1B telemetry; length from the type)
                sized    size, type/addr, data, CRC              (HADES-SA, HADES-L; length from the size byte)
                voice    0x25, type/addr (type 15 or 11), number, 35 bytes   (CODEC2; no CRC)
              Candidates are first checked exactly; bit repair is only tried when every candidate's bits have arrived, and
              with the fewest flips first, so a true frame beats a chance CRC match of a wrong layout."""
              frames = []
              while True:
                  s = ''.join(map(str, self.bits[self.scan:]))
                  j = s.find(SYNC_BITS)
                  if j < 0:
                      # keep a tail so a sync split across pushes is still found
                      self.scan = max(self.scan, len(self.bits) - len(SYNC_BITS) + 1)
                      break
                  a = self.scan + j
                  if len(self.bits) < a + 32:
                      self.scan = a
                      break
                  b0, b1 = self._byte_at(a + 16), self._byte_at(a + 24)
                  if b0 == VOICE_SIZE_BYTE and (b1 >> 4) in VOICE_TYPES:        # CODEC2 voice: exclusive, no CRC
                      nbits = 8 * (1 + VOICE_SIZE_BYTE)
                      if len(self.bits) < a + 16 + nbits:
                          self.scan = a
                          break
                      payload = bits_to_bytes(self.bits[a + 40:a + 16 + nbits])
                      self.nframes += 1
                      frames.append({'type': b1 >> 4, 'src': b1 & 15, 'src_name': SOURCES.get(b1 & 15, 'unknown'),
                                     'type_name': type_name(b1 & 15, b1 >> 4), 'framing': 'sized', 'voice': True,
                                     'baud': int(self.baud), 'number': self._byte_at(a + 32), 'payload': payload.hex(),
                                     'raw': payload.hex(), 'plain': payload.hex(), 'flips': [], 'crc_ok': None,
                                     'sclock': None, 'nocrc': True})
                      self.scan = a + 16 + nbits
                      continue
                  if b0 in PN9_SIZES and (b1 >> 4) == 13 and (b1 & 15) in SOURCES:       # PN9 link test: no CRC
                      nbits = 8 * (1 + b0)
                      if len(self.bits) < a + 16 + nbits:
                          self.scan = a
                          break
                      raw = bits_to_bytes(self.bits[a + 16:a + 16 + nbits])
                      plain = raw[1:]                              # the PN9 pattern goes out as is (no scrambler): verified on air
                      self.nframes += 1
                      frames.append(self._frame_dict('sized', plain, raw, [], None))
                      self.scan = a + 16 + nbits
                      continue
                  cands = []
                  if (b0 >> 4) in TOTAL_BYTES and (b0 & 15) in LEGACY_SOURCES:
                      cands.append(('legacy', 8 * (TOTAL_BYTES[b0 >> 4] - PRE_BYTES), 0))
                  if b0 == SSDV_SIZE_BYTE and (b1 >> 4) == 10 and (b1 & 15) in SOURCES:           # SSDV image packet
                      cands.append(('ssdv', 8 * (1 + b0), 1))
                  elif 3 <= b0 <= 255 and (b1 >> 4) >= 1 and (b1 & 15) in SOURCES:
                      cands.append(('sized', 8 * (1 + b0), 1))
                  gidx = self.dropped + a
                  cands = [c for c in cands if (gidx, c[0]) not in self.failed]
                  cands.sort(key=lambda c: c[1])
                  have = [c for c in cands if len(self.bits) >= a + 16 + c[1]]
                  pending = len(have) < len(cands)
                  hit = None
                  for kind, nbits, crc_from in have:                           # 1. exact CRC, shortest layout first
                      r = self._attempt(self.bits[a + 16:a + 16 + nbits], None, crc_from, 0, 0, kind)
                      if r:
                          hit = (kind, nbits) + r
                          break
                  if hit is None and pending:
                      self.scan = a                                            # wait for the longer layouts' bits
                      break
                  if hit is None:                                              # 1b. SSDV: Reed-Solomon repair of damaged bytes
                      for kind, nbits, crc_from in have:
                          if kind == 'ssdv':
                              raw = bits_to_bytes(self.bits[a + 16:a + 16 + nbits])
                              fixed = ssdv_repair(raw)
                              if fixed:
                                  hit = (kind, nbits, fixed[0], raw, [])
                                  break
                  if hit is None and self.max_flips > 0:                       # 2. bit repair, fewest flips first
                      for nf in range(1, self.max_flips + 1):
                          for kind, nbits, crc_from in have:
                              r = self._attempt(self.bits[a + 16:a + 16 + nbits], self.soft[a + 16:a + 16 + nbits],
                                                crc_from, nf, self.flip_candidates, kind)
                              if r:
                                  hit = (kind, nbits) + r
                                  break
                          if hit:
                              break
                  if hit is not None:
                      kind, nbits, plain, raw, flips = hit
                      self.nframes += 1
                      frames.append(self._frame_dict('sized' if kind == 'ssdv' else kind, plain, raw, flips, True))
                      self.scan = a + 16 + nbits
                      continue
                  for kind, nbits, crc_from in have:
                      self.failed.add((gidx, kind))
                  sized = [c for c in have if c[0] == 'sized']
                  if self.emit_unverified and sized:                           # for exploring new satellites / packet types
                      nbits = sized[0][1]
                      raw = bits_to_bytes(self.bits[a + 16:a + 16 + nbits])
                      plain = raw[1:2] + descramble(raw[2:-2])
                      self.nframes += 1
                      frames.append(self._frame_dict('sized', plain, raw, [], False))
                      self.scan = a + 16 + nbits
                      continue
                  self.scan = a + 1
              # bound memory
              if len(self.bits) > 8192:
                  drop = len(self.bits) - 4096
                  del self.bits[:drop]
                  del self.soft[:drop]
                  self.dropped += drop
                  self.scan = max(0, self.scan - drop)
                  self.failed = {k for k in self.failed if k[0] >= self.dropped}
              return frames

      class MultiBaudDeframer(object):
          """Runs one Unne1bDeframer per baud rate on the same stream, because HADES-SA alternates between 800 and 200 baud
          (and HADES-L can be switched by telecommand).  A frame is reported by whichever rate it is received at."""

          def __init__(self, fs=10000.0, bauds=(200.0,), **kw):
              self.deframers = [Unne1bDeframer(fs=fs, baud=b, **kw) for b in bauds]

          @property
          def nframes(self):
              return sum(d.nframes for d in self.deframers)

          def push(self, x):
              """Returns (demodulated float stream of the first baud rate, frames from all rates)."""
              first, frames = None, []
              for i, d in enumerate(self.deframers):
                  dd, fr = d.push(x)
                  if i == 0:
                      first = dd
                  frames.extend(fr)
              return first, frames


      def parse_bauds(value):
          """'auto' -> (200, 800); '800' -> (800,); '200,800' -> (200, 800); a number or a list of numbers also works."""
          if isinstance(value, (int, float)):
              return (float(value),)
          if isinstance(value, (list, tuple)):
              return tuple(float(v) for v in value)
          v = str(value).strip().lower()
          if v in ('', 'auto'):
              return (200.0, 800.0)
          out = tuple(float(t) for t in v.replace(' ', '').split(',') if t)
          if not out or any(b <= 0 for b in out):
              raise ValueError('baud must be "auto", a number, or a comma separated list (got %r)' % (value,))
          return out


      def format_frame(fr, dll=None):
          ptype, src = fr['type'], fr['src']
          name = fr.get('type_name') or type_name(src, ptype)
          # UNNE-1B keeps its original header text; other satellites are named by their source address
          if src == 0xC:
              lead = 'UNNE-1B packet type %d (%s)' % (ptype, name)
              tail = ' from %s' % fr['src_name']
          else:
              lead = '%s packet type %d (%s)' % (fr['src_name'], ptype, name)
              tail = ''
          if fr.get('voice'):
              return ('=== %s frame #%d%s [no CRC in this packet type] ===\n'
                      'payload (35 bytes, 280 bits): %s' % (lead.replace('(%s)' % name, '(%s)' % name), fr['number'],
                                                            tail, fr['payload']))
          crc = fr.get('crc_ok', True)
          status = 'CRC OK' if crc else ('no CRC in this packet type' if crc is None else 'CRC FAIL - unverified')
          if fr['flips']:
              status += ', corrected bits %s' % fr['flips']
          lines = ['=== %s%s  [%s] ===' % (lead, tail, status)]
          if fr.get('framing') == 'sized' or fr.get('baud', 200) != 200:
              lines.append('link: %s baud%s' % (fr.get('baud', 200),
                                                (', length byte %d' % fr['size']) if fr.get('size') is not None else ''))
          if fr['sclock'] is not None:
              sc = fr['sclock']
              lines.append('sclock: %d s  (%dd %02d:%02d:%02d since boot)' % (
                  sc, sc // 86400, sc % 86400 // 3600, sc % 3600 // 60, sc % 60))
          text = None
          dll_ok = src in DLL_SATELLITES and fr.get('crc_ok', True) and fr.get('framing', 'legacy') == 'legacy'
          if dll is not None and dll_ok:
              try:
                  text = dll.decode(ptype, src, bytes.fromhex(fr['plain']))
              except Exception as e:                       # noqa
                  text = '[DLL decode failed: %s]' % e
          if not text and crc is not False:
              text = _native_text(fr)                      # HADES-SA / HADES-L: decoded here, no DLL needed
          if text:
              lines.append(text.rstrip())
          else:
              scrambled = not (fr.get('framing') == 'sized' and ptype in (10, 13))
              lines.append('data (%s): %s' % ('descrambled' if scrambled else 'as received, not scrambled', fr['plain'][2:]))
              lines.append('whole frame (type/address byte first, no CRC): %s' % ' '.join(
                  fr['plain'][i:i + 2] for i in range(0, len(fr['plain']), 2)).upper())
              if dll_ok:
                  lines.append("(the frame is decoded and CRC-checked; the field names (voltages, temperatures ...) need AMSAT-EA's decoder: "
                               'pass --dll hadesr.dll)')
              elif crc is False:
                  lines.append('(CRC failed: not decoded)')
              else:
                  lines.append('(field-by-field decoding for %s is not implemented yet - raw bytes shown)' % fr['src_name'])
          return '\n'.join(lines)


      def _native_text(fr):
          """The labelled text of the native decoders for HADES-SA / HADES-L frames (None for other satellites or packet types),
          without the time line, which is not known here."""
          try:
              try:
                  decode, native, Context = decode_frame, NATIVE_SOURCES, Ctx          # noqa: F821  genesis.py shares the namespace
              except NameError:
                  from .genesis import decode_frame as decode, NATIVE_SOURCES as native, Ctx as Context
              if fr['src'] not in native:
                  return None
              res = decode(fr['type'], fr['src'], bytes.fromhex(fr['plain']), Context(0))
          except Exception:                                # noqa: genesis not available, or a frame the decoders cannot handle
              return None
          if res is None or not res[0]:
              return None
          body = res[0].split('\n', 1)[1] if res[0].startswith('***') else res[0]
          out = []
          for line in body.split('\n'):
              if 'Data matching rate' in line and line[:8].isdigit():        # the PN9 line starts with the (unknown here) time
                  line = line[line.index('Data matching rate'):]
              out.append(line)
          return '\n'.join(out).rstrip('\n')


      # ----------------------------------------------------------------------------
      # GNU Radio Embedded Python block: adaptive FSK tracker / mixer
      # ----------------------------------------------------------------------------
      import pmt
      from gnuradio import gr


      class blk(gr.sync_block):
          """Finds the UNNE-1B FSK signal anywhere in the band, tracks its Doppler drift and mixes
          it to 0 Hz.  Output 0: complex baseband (delayed by delay_s).  Output 1: tracked centre in Hz."""

          def __init__(self, samp_rate=50000.0, min_db=15.0, delay_s=1.2):
              gr.sync_block.__init__(self, name='UNNE-1B adaptive FSK tracker',
                                     in_sig=[np.complex64], out_sig=[np.complex64, np.float32])
              self.message_port_register_out(pmt.intern('centre'))
              self.fs = float(samp_rate)
              self.tr = FskCentreTracker(self.fs, delay_s=float(delay_s), min_db=float(min_db))
              d = self.tr.delay
              self.qy = np.zeros(d, np.complex64)      # pre-fill = look-ahead delay
              self.qc = np.zeros(d, np.float32)
              self.nacc = 0
              self.last_msg_t = -1e9

          def work(self, input_items, output_items):
              x = input_items[0]
              n = len(x)
              y, c = self.tr.push(x)
              self.qy = np.concatenate([self.qy, y])
              self.qc = np.concatenate([self.qc, c])
              k = min(n, len(self.qy))
              output_items[0][:k] = self.qy[:k]
              output_items[1][:k] = self.qc[:k]
              if k < n:
                  output_items[0][k:n] = 0
                  output_items[1][k:n] = 0
              self.qy = self.qy[k:]
              self.qc = self.qc[k:]
              na = len(self.tr.acc_tags)
              if na > self.nacc:
                  t = self.tr.acc_tags[-1] / self.fs
                  cen = self.tr.acc_cent[-1]
                  if t - self.last_msg_t > 5.0:
                      print('[hadesx] FSK signal found at %+.0f Hz (input time %.1f s)' % (cen, t), flush=True)
                      self.message_port_pub(pmt.intern('centre'), pmt.from_double(float(cen)))
                  self.last_msg_t = t
                  self.nacc = na
              return n
    comment: 'Adaptive FSK tracker: finds the two-tone FSK anywhere in the 50 kHz band, follows Doppler, mixes it to 0 Hz. Look-ahead 1.2 s. Output 1 = tracked centre (Hz).'
    delay_s: lookahead_s
    min_db: min_db
    samp_rate: samp_rate
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    comment: Low-pass +-2.35 kHz and decimate by 5
    decim: decim
    taps: firdes.low_pass(1.0, samp_rate, 2350, 1200)
    type: ccc
  states: {}
- name: epy_block_dec
  id: epy_block
  parameters:
    _source_code: |
      # HADESx Decoder  -  https://github.com/N6RFM/HADESx-Decoder
      # Authors: N6RFM, with Claude (an AI assistant made by Anthropic).
      # Licence: MIT (see LICENSE).
      # Built on AMSAT-EA's open documentation and source code (CC BY 4.0): see NOTICE.md. Frame format, scrambler, CRC and the CODEC2
      # voice key come from their documents and decoder. SSDV: the format of Philip Heron's ssdv (NOTICE.md, section 10).
      import time
      import struct
      import re
      from bisect import bisect_left
      from itertools import combinations
      import numpy as np

      # ----------------------------------------------------------------------------
      # UNNE-1B (HADES-E2) FSK telemetry and CODEC2 voice decoder  --  core library
      #
      # This module is deliberately ONE self-contained file (numpy is the only hard
      # dependency) so that tools/build_grc.py can embed it verbatim in the GNU Radio
      # flowgraph.  Sections:
      #   1. protocol constants, CRC, scrambler, voice helpers
      #   2. optional emulation of AMSAT-EA's hadesr.dll (needs unicorn + pefile)
      #   3. FskCentreTracker  - finds / follows the FSK signal anywhere in the band
      #   4. Unne1bDeframer    - demodulator, clock recovery, sync, CRC, bit-error fixing
      #   5. formatting helpers
      #
      # Air interface (AMSAT-EA, "UNNE-1B Descripcion de transmisiones" v1.01):
      #   200 bd 2-FSK, lower tone = mark = 1, bytes MSB first
      #   128-bit 0xAA training, sync 0xBF35, type|address byte, data, CRC16
      #   data is scrambled (x^17 + x^12 + 1, state 0x2C350000, bit 0 of every byte is
      #   skipped - verified against AMSAT-EA's reference genesis_scrambler.c)
      #   CRC-CCITT-FALSE is computed over the *scrambled* bytes (type/addr .. data)
      #
      # Credits: the frame format follows AMSAT-EA's UNNE-1B transmission document; the voice XOR
      # key and padding rule come from AMSAT-EA's HADES-SA_SpinnyONE sources ((c) AMSAT EA, CC BY 4.0);
      # scrambler and CRC behaviour follow AMSAT-EA's genesis_scrambler.c / genesis_crc.c
      # (Gabriel Otero Perez).  Full attribution and the list of changes: NOTICE.md.
      # ----------------------------------------------------------------------------

      __all__ = [
          'SYNC_BITS', 'TOTAL_BYTES', 'PRE_BYTES', 'TYPE_NAMES', 'DLL_FUNCS', 'SOURCES',
          'crc16_ccitt_false', 'ssdv_crc_ok', 'ssdv_plain', 'ssdv_repair', 'rs_ssdv_correct', 'rs_ssdv_parity', 'descramble', 'scramble', 'bits_to_bytes', 'check_frame',
          'VOICE_PAYLOAD_BYTES', 'VOICE_XOR_KEY', 'voice_unwhiten', 'voice_pad_700c', 'voice_assemble',
          'DllDecoder', 'FskCentreTracker', 'Unne1bDeframer', 'MultiBaudDeframer', 'parse_bauds', 'format_frame',
          'type_name', 'check_unne_dll', 'DLL_SATELLITES', 'LEGACY_SOURCES', 'VOICE_TYPES', 'VOICE_SIZE_BYTE', 'SSDV_SIZE_BYTE', 'PN9_SIZES', 'TYPE_NAMES_BY_SOURCE',
      ]

      SYNC_BITS = '1011111100110101'          # 0xBF35

      # total packet size in bytes (training + sync + type/addr + data + crc) per spec
      TOTAL_BYTES = {1: 49, 2: 35, 3: 47, 4: 53, 5: 45, 6: 153, 8: 49, 9: 141,
                     10: 35, 12: 82, 14: 56}
      PRE_BYTES = 18                           # 16 training + 2 sync

      TYPE_NAMES = {1: 'Power', 2: 'Temperature', 3: 'Status', 4: 'Power stats',
                    5: 'Temperature stats', 6: 'Sun sensors', 8: 'Antenna deploy',
                    9: 'Extended power (INA)', 10: 'Nebrija game payload',
                    12: 'Ephemeris', 14: 'Time series', 15: 'CODEC2 voice'}

      DLL_FUNCS = {1: 'visualiza_powerpacket', 2: 'visualiza_temppacket',
                   3: 'visualiza_statuspacket', 4: 'visualiza_powerstatspacket',
                   5: 'visualiza_tempstatspacket', 6: 'visualiza_sunvectorpacket',
                   8: 'visualiza_deploypacket', 9: 'visualiza_ine',
                   10: 'visualiza_nebrijapayload_data_packet',
                   12: 'visualiza_efemeridespacket',
                   14: 'visualiza_time_series_packet'}

      # Source address nibble -> satellite.  UNNE-1B (0xC), MARIA-G (0xB), HADES-ICM (2) are from AMSAT-EA's UNNE-1 /
      # MARIA-G / HADES-R / HADES-ICM document; HADES-SA = 3 is what AMSAT-EA's HADES-SA decoder and its sample frames use.
      # HADES-L: its document gives 5 in the packet tables and 3 in the text - 5 is assumed until real frames settle it.
      SOURCES = {0xC: 'UNNE-1B', 0xB: 'MARIA-G', 2: 'HADES-ICM', 3: 'HADES-SA', 5: 'HADES-L'}

      # Satellites whose frame contents the optional hadesr.dll decodes (UNNE-1, MARIA-G, HADES-R/ICM family).
      DLL_SATELLITES = (0xC, 0xB, 2)
      # Satellites that send the older layout without a length byte (type/addr, data, CRC).
      LEGACY_SOURCES = (0xC, 0xB, 2)

      # Packet type names that differ from the generic TYPE_NAMES above, by source address.
      TYPE_NAMES_BY_SOURCE = {
          3: {7: 'Experiment payload', 8: 'Antenna deploy', 9: 'Extended power (INA)', 10: 'SSDV image packet',
              11: 'CODEC2 voice', 12: 'Ephemeris', 13: 'PN9 link test', 14: 'Time series', 15: 'BBS message'},
          5: {7: 'Lofith payload', 8: 'Antenna deploy', 9: 'Extended power (INA)', 11: 'CODEC2 voice', 12: 'Ephemeris',
              13: 'PN9 link test', 14: 'Time series', 15: 'ICM message'},
      }


      def type_name(src, ptype):
          """Human-readable packet type for a source address."""
          return TYPE_NAMES_BY_SOURCE.get(src, {}).get(ptype) or TYPE_NAMES.get(ptype, '?')


      # CODEC2 voice packet type: 15 on UNNE-1B, 11 on HADES-SA / HADES-L (all carry size 37 = type/addr + number + 35 bytes)
      VOICE_TYPES = (11, 15)
      SSDV_SIZE_BYTE = 251                   # HADES-SA SSDV image packets: type 10, 251 bytes after the size byte
      PN9_SIZES = (249, 255)                 # PN9 link-test packets (HADES-SA 249; the HADES-L document says 255)
      VOICE_SIZE_BYTE = 37


      def _make_crc_table():
          tab = []
          for i in range(256):
              c = i << 8
              for _ in range(8):
                  c = ((c << 1) ^ 0x1021) & 0xFFFF if c & 0x8000 else (c << 1) & 0xFFFF
              tab.append(c)
          return tab


      _CRC_TAB = _make_crc_table()


      def crc16_ccitt_false(data, init=0xFFFF):
          c = init
          for b in data:
              c = ((c << 8) & 0xFFFF) ^ _CRC_TAB[((c >> 8) ^ b) & 0xFF]
          return c


      def ssdv_crc_ok(packet):
          """Check a 256-byte SSDV packet: CRC-32 over bytes 1..219, stored big-endian at 220..223."""
          import zlib
          return len(packet) >= 224 and (zlib.crc32(packet[1:220]) & 0xFFFFFFFF) == int.from_bytes(packet[220:224], 'big')


      def _ssdv_layouts(body):
          """The ways the 251 SSDV bytes (type/address first) might have been scrambled; each gives a candidate."""
          return [body,                                                         # 0: sent as is
                  body[:1] + descramble(body[1:]),                              # 1: everything after type/address scrambled
                  body[:1] + descramble(body[1:215]) + body[215:],              # 2: data scrambled, CRC-32 and FEC as is
                  body[:1] + descramble(body[1:219]) + body[219:],              # 3: data and CRC-32 scrambled, FEC as is
                  body[:1] + descramble(body[1:215]) + body[215:219] + descramble(body[219:])]   # 4: CRC-32 as is, FEC scrambled


      def ssdv_plain(raw):
          """HADES-SA SSDV frame: `raw` = size byte + type/address + 250 bytes (the standard 256-byte SSDV packet is
          55 66 BF 35 FB followed by the 251 bytes after the size byte).  Returns those 251 bytes (type/address first) when
          the packet's own CRC-32 verifies, else None.  Whether the satellite scrambles the SSDV bytes is not settled
          (the spec exempts "training, sync, type and CRC"), so each plausible layout is tried; a CRC-32 pass is proof."""
          body = raw[1:252]
          if len(body) < 251:
              return None
          head = b'\x55\x66\xbf\x35' + raw[0:1]
          good = [cand for cand in _ssdv_layouts(body) if ssdv_crc_ok(head + cand)]
          for cand in good:                       # the CRC-32 does not cover the FEC: prefer the layout whose FEC is consistent
              if rs_ssdv_parity((head + cand)[1:224]) == cand[219:]:
                  return cand
          return good[0] if good else None


      # Reed-Solomon RS(255,223) of the SSDV standard (fsphil/ssdv, libfec decode_rs_8 CCSDS parameters: field polynomial
      # 0x187, first root 112, root step 11, 32 parity bytes, conventional basis).  Verified against the FEC of a real
      # HADES-SA packet.  Corrects up to 16 wrong bytes in the 255 bytes after the 0x55 sync byte.
      _RS_EXP = [0] * 512
      _RS_LOG = [0] * 256
      _x = 1
      for _i in range(255):
          _RS_EXP[_i] = _x
          _RS_LOG[_x] = _i
          _x <<= 1
          if _x & 0x100:
              _x ^= 0x187
      for _i in range(255, 512):
          _RS_EXP[_i] = _RS_EXP[_i - 255]


      def _gmul(a, b):
          return 0 if a == 0 or b == 0 else _RS_EXP[_RS_LOG[a] + _RS_LOG[b]]


      def _gdiv(a, b):
          return 0 if a == 0 else _RS_EXP[(_RS_LOG[a] - _RS_LOG[b]) % 255]


      def rs_ssdv_parity(data223):
          g = [1]
          for i in range(32):
              r = _RS_EXP[(11 * (112 + i)) % 255]
              ng = [0] * (len(g) + 1)
              for j, c in enumerate(g):
                  ng[j] ^= c
                  ng[j + 1] ^= _gmul(c, r)
              g = ng
          par = [0] * 32
          for d in data223:
              fb = d ^ par[0]
              par = par[1:] + [0]
              if fb:
                  for j in range(32):
                      par[j] ^= _gmul(fb, g[j + 1])
          return bytes(par)


      def rs_ssdv_correct(block):
          """block = 255 bytes (data 223 + parity 32).  Returns (corrected 255 bytes, number of bytes fixed) or None."""
          n = 255
          blk = list(block)
          syn = []
          for i in range(32):
              r = _RS_EXP[(11 * (112 + i)) % 255]
              acc = 0
              for c in blk:
                  acc = _gmul(acc, r) ^ c
              syn.append(acc)
          if not any(syn):
              return bytes(blk), 0
          lam, prev, L, m, b = [1], [1], 0, 1, 1                 # Berlekamp-Massey
          for k in range(32):
              d = syn[k]
              for i in range(1, L + 1):
                  if i < len(lam):
                      d ^= _gmul(lam[i], syn[k - i])
              if d == 0:
                  m += 1
                  continue
              t = lam[:]
              coef = _gdiv(d, b)
              shifted = [0] * m + [_gmul(coef, c) for c in prev]
              lam = lam + [0] * (len(shifted) - len(lam))
              for i, c in enumerate(shifted):
                  lam[i] ^= c
              if 2 * L <= k:
                  L, prev, b, m = k + 1 - L, t, d, 1
              else:
                  m += 1
          if L > 16:
              return None
          lam = lam[:L + 1] + [0] * max(0, L + 1 - len(lam))
          pos = []
          for idx in range(n):                                   # error at index idx has locator X = alpha^(11 * (254 - idx))
              xinv = _RS_EXP[(-11 * (254 - idx)) % 255]
              v, pw = 0, 1
              for c in lam:
                  v ^= _gmul(c, pw)
                  pw = _gmul(pw, xinv)
              if v == 0:
                  pos.append(idx)
          if len(pos) != L:
              return None
          omega = [0] * 32                                       # Omega = S(x) * Lambda(x) mod x^32
          for i in range(32):
              acc = 0
              for j in range(min(i, L) + 1):
                  acc ^= _gmul(lam[j], syn[i - j])
              omega[i] = acc
          for idx in pos:
              x = _RS_EXP[(11 * (254 - idx)) % 255]
              xinv = _RS_EXP[(-11 * (254 - idx)) % 255]
              num, pw = 0, 1
              for c in omega:
                  num ^= _gmul(c, pw)
                  pw = _gmul(pw, xinv)
              den, pw = 0, 1                                     # Lambda'(xinv): odd terms only
              for j in range(1, len(lam), 2):
                  den ^= _gmul(lam[j], _RS_EXP[(_RS_LOG[xinv] * (j - 1)) % 255] if xinv else 0)
              if den == 0:
                  return None
              # magnitude = X^(1 - fcr) * Omega(Xinv) / Lambda'(Xinv), fcr = 112
              mag = _gmul(_gdiv(num, den), _RS_EXP[((1 - 112) * _RS_LOG[x]) % 255])
              blk[idx] ^= mag
          again = rs_ssdv_parity(bytes(blk[:223]))
          if again != bytes(blk[223:]):
              return None
          return bytes(blk), len(pos)


      def ssdv_repair(raw):
          """Like ssdv_plain(), but lets the Reed-Solomon code repair damaged bytes first.  Returns
          (251 plain bytes, number of bytes repaired) or None.  The result is accepted only if its CRC-32 then verifies."""
          body = raw[1:252]
          if len(body) < 251:
              return None
          head = b'\x55\x66\xbf\x35' + raw[0:1]
          for cand in _ssdv_layouts(body):
              packet = head + cand
              fixed = rs_ssdv_correct(packet[1:])
              if fixed is not None and ssdv_crc_ok(b'\x55' + fixed[0]):
                  return fixed[0][4:], fixed[1]
          return None


      def descramble(data, init=0x2C350000):
          """Self-synchronising descrambler.  Behaviour defined by AMSAT-EA's genesis_scrambler.c
          (Gabriel Otero Perez, (c) AMSAT EA, CC BY 4.0, github.com/AMSAT-EA/HADES-SA_SpinnyONE);
          this is an independent Python implementation, checked against that C code."""
          reg = init
          out = bytearray(data)
          for k in range(len(out)):
              b = out[k]
              for i in range(7, 0, -1):            # bits 7..1 (bit 0 is left alone)
                  inb = (b >> i) & 1
                  fb = ((reg >> 16) & 1) ^ inb ^ ((reg >> 11) & 1)
                  if fb:
                      b |= (1 << i)
                  else:
                      b &= ~(1 << i)
                  reg = ((reg << 1) | inb) & 0x1FFFF
              out[k] = b
          return bytes(out)


      def bits_to_bytes(bits):
          n = len(bits) // 8 * 8
          return bytes(int(''.join(map(str, bits[i:i + 8])), 2) for i in range(0, n, 8))


      def check_frame(raw):
          """raw = bytes after sync (type/addr .. data .. crc). Returns (ok, plain)."""
          body = raw[:-2]
          rx = (raw[-2] << 8) | raw[-1]
          ok = crc16_ccitt_false(body) == rx
          plain = raw[:1] + descramble(raw[1:-2])
          return ok, plain


      def scramble(data, init=0x2C350000):
          """Inverse of descramble() (what the satellite does before transmitting)."""
          reg = init
          out = bytearray(data)
          for k in range(len(out)):
              b = out[k]
              for i in range(7, 0, -1):
                  inb = (b >> i) & 1
                  o = inb ^ ((reg >> 16) & 1) ^ ((reg >> 11) & 1)
                  if o:
                      b |= (1 << i)
                  else:
                      b &= ~(1 << i)
                  reg = ((reg << 1) | o) & 0x1FFFF
              out[k] = b
          return bytes(out)


      # ---- CODEC2 voice (type 15) helpers ---------------------------------------
      # Each voice packet: sync(2) | size=0x25 | 0xF<<4|addr | frame number | 35 payload bytes
      # The 35 bytes are XOR-whitened with a fixed keystream and hold ten 28-bit Codec2 700C frames.
      # Attribution: the key values below are copied unchanged from AMSAT-EA's HADES-SA_SpinnyONE
      # repository, byte_version/main.c (visualiza_codec2, xor_codec2[35]), (c) AMSAT EA 2026,
      # licensed CC BY 4.0 (https://creativecommons.org/licenses/by/4.0/); the 28-bit -> 4-byte
      # padding rule is re-implemented from add_padding_codec2() in the same file.
      VOICE_PAYLOAD_BYTES = 35
      VOICE_XOR_KEY = bytes([
          0xed, 0x15, 0xd5, 0x3b, 0x34, 0x70, 0xe0, 0xfd, 0xed, 0x83, 0x90, 0xdb,
          0xaa, 0x2e, 0x25, 0xd6, 0x5e, 0x81, 0x41, 0x86, 0xbd, 0x67, 0x79, 0x5d,
          0x70, 0xa1, 0x13, 0xce, 0x50, 0x0c, 0x19, 0xca, 0xfb, 0x44, 0x0d])
      C2_700C_FRAME_BITS = 28
      C2_700C_FRAMES_PER_PACKET = 10


      def voice_unwhiten(payload):
          """Remove the fixed XOR keystream from a 35-byte voice payload."""
          return bytes(a ^ b for a, b in zip(payload, VOICE_XOR_KEY))


      def voice_pad_700c(payload_unwhitened):
          """35 bytes -> 10 frames x 4 bytes (28 bits + 4 zero bits), the layout c2dec reads."""
          bits = np.unpackbits(np.frombuffer(payload_unwhitened, dtype=np.uint8))
          out = bytearray()
          for k in range(C2_700C_FRAMES_PER_PACKET):
              fb = np.zeros(32, dtype=np.uint8)
              fb[:C2_700C_FRAME_BITS] = bits[k * C2_700C_FRAME_BITS:(k + 1) * C2_700C_FRAME_BITS]
              out += np.packbits(fb).tobytes()
          return bytes(out)


      def voice_assemble(packets):
          """packets: {frame_number: 35 whitened bytes}.  Returns (c2dec input bytes, missing numbers).
          Missing packets become 40 zero bytes (10 silent frames), like AMSAT-EA's merge tool."""
          if not packets:
              return b'', []
          first, last = min(packets), max(packets)
          out, missing = bytearray(), []
          for n in range(first, last + 1):
              if n in packets:
                  out += voice_pad_700c(voice_unwhiten(packets[n]))
              else:
                  out += bytes(4 * C2_700C_FRAMES_PER_PACKET)
                  missing.append(n)
          return bytes(out), missing


      # ----------------------------------------------------------------------------
      # Optional: use the real hadesr.dll (AMSAT-EA) inside an x86 emulator so that the
      # official text decoder can be used on Linux without Wine.  Needs: unicorn, pefile
      # ----------------------------------------------------------------------------
      def check_unne_dll(path, export_names):
          """--dll takes hadesr.dll, the decoder of the UNNE-1B package. The HADES-SA and HADES-L packages have DLLs with the same style of
          names but different functions: refuse them with a clear message instead of printing nonsense."""
          names = set(export_names)
          if 'visualiza_nebrijapayload_data_packet' in names:
              return
          base = path.replace('\\', '/').split('/')[-1]
          if 'visualiza_lofith' in names:
              what = "%s is the HADES-L package's decoder" % base
          elif 'visualiza_ssdv' in names:
              what = "%s is the HADES-SA package's decoder" % base
          else:
              what = '%s is not the UNNE-1B package\'s hadesr.dll' % base
          raise ValueError('%s. --dll takes hadesr.dll from the UNNE-1B package; HADES-SA and HADES-L need no DLL (this program decodes '
                           'them itself).' % what)


      class DllDecoder:
          def __init__(self, path):
              import pefile
              from unicorn import Uc, UC_ARCH_X86, UC_MODE_32, UC_HOOK_CODE
              from unicorn.x86_const import (UC_X86_REG_ESP, UC_X86_REG_EIP,
                                             UC_X86_REG_EAX)
              self._u = (UC_X86_REG_ESP, UC_X86_REG_EIP, UC_X86_REG_EAX)
              pe = pefile.PE(path)
              base = pe.OPTIONAL_HEADER.ImageBase
              mu = Uc(UC_ARCH_X86, UC_MODE_32)
              size = (pe.OPTIONAL_HEADER.SizeOfImage + 0xFFF) & ~0xFFF
              mu.mem_map(base, size)
              mu.mem_write(base, pe.header)
              for s in pe.sections:
                  mu.mem_write(base + s.VirtualAddress, s.get_data())
              self.exp = {e.name.decode(): base + e.address
                          for e in pe.DIRECTORY_ENTRY_EXPORT.symbols if e.name}
              check_unne_dll(path, self.exp)
              self.FAKE = 0x10000000
              mu.mem_map(self.FAKE, 0x10000)
              self.imp = {}
              n = 0
              for ent in pe.DIRECTORY_ENTRY_IMPORT:
                  for i in ent.imports:
                      addr = self.FAKE + n * 16
                      n += 1
                      mu.mem_write(i.address, struct.pack('<I', addr))
                      mu.mem_write(addr, b'\xc3')
                      self.imp[addr] = i.name.decode() if i.name else str(i.ordinal)
              self.STACK = 0x7000000
              mu.mem_map(self.STACK, 0x200000)
              self.HEAP = 0x8000000
              mu.mem_map(self.HEAP, 0x400000)
              self.mu = mu
              self.out = []
              mu.hook_add(UC_HOOK_CODE, self._hook, begin=self.FAKE, end=self.FAKE + 0x10000)

          def _rd(self, a, n):
              return bytes(self.mu.mem_read(a, n))

          def _cstr(self, a):
              s = b''
              while True:
                  c = self._rd(a, 1)
                  if c == b'\0':
                      return s
                  s += c
                  a += 1

          def _arg(self, k):
              esp = self.mu.reg_read(self._u[0])
              return struct.unpack('<I', self._rd(esp + 4 + 4 * k, 4))[0]

          def _cfmt(self, fmt, k):
              res = b''
              pos = 0
              pat = re.compile(rb'%([-+ #0]*)(\d*)(?:\.(\d+))?(l|h|ll)?([diuxXcsfeEgG%])')
              for m in pat.finditer(fmt):
                  res += fmt[pos:m.start()]
                  pos = m.end()
                  flags, w, pr, _l, conv = m.groups()
                  if conv == b'%':
                      res += b'%'
                      continue
                  f = '%' + (flags or b'').decode() + (w or b'').decode() + \
                      ('.' + pr.decode() if pr else '')
                  if conv in b'feEgG':
                      lo, hi = self._arg(k), self._arg(k + 1)
                      k += 2
                      v = struct.unpack('<d', struct.pack('<II', lo, hi))[0]
                      res += ((f + conv.decode()) % v).encode()
                      continue
                  v = self._arg(k)
                  k += 1
                  if conv == b's':
                      res += self._cstr(v)
                  elif conv == b'c':
                      res += bytes([v & 255])
                  else:
                      if conv in b'di' and v >= 2 ** 31:
                          v -= 2 ** 32
                      res += ((f + conv.decode().replace('i', 'd')) % v).encode()
              return res + fmt[pos:]

          @staticmethod
          def _tm(t, gm):
              s = time.gmtime(t) if gm else time.localtime(t)
              return struct.pack('<9I', s.tm_sec, s.tm_min, s.tm_hour, s.tm_mday,
                                 s.tm_mon - 1, s.tm_year - 1900,
                                 (s.tm_wday + 1) % 7, s.tm_yday - 1, max(s.tm_isdst, 0))

          def _hook(self, mu, addr, sz, ud):
              if addr not in self.imp:
                  return
              name = self.imp[addr].lstrip('_')
              esp = mu.reg_read(self._u[0])
              ret = 0
              if name in ('time', 'time64', 'time32'):
                  ret = int(time.time())
                  t = self._arg(0)
                  if t:
                      mu.mem_write(t, struct.pack('<I', ret))
              elif name in ('localtime', 'localtime64', 'localtime32', 'gmtime',
                            'gmtime64', 'gmtime32'):
                  tp = self._arg(0)
                  t = struct.unpack('<i', self._rd(tp, 4))[0]
                  try:
                      blob = self._tm(t, name.startswith('gm'))
                      ret = self.HEAP + 0x100
                      mu.mem_write(ret, blob)
                  except (OverflowError, OSError, ValueError):
                      ret = 0
              elif name == 'sprintf':
                  s = self._cfmt(self._cstr(self._arg(1)), 2)
                  mu.mem_write(self._arg(0), s + b'\0')
                  ret = len(s)
              elif name == 'printf':
                  s = self._cfmt(self._cstr(self._arg(0)), 1)
                  self.out.append(s.decode('latin1'))
                  ret = len(s)
              elif name == 'puts':
                  self.out.append(self._cstr(self._arg(0)).decode('latin1') + '\n')
              elif name == 'putchar':
                  self.out.append(chr(self._arg(0) & 255))
              elif name in ('fflush', 'setvbuf'):
                  ret = 0
              elif name == 'fprintf':                      # fprintf(stream, format, ...): every stream goes to the captured text
                  s = self._cfmt(self._cstr(self._arg(1)), 2)
                  self.out.append(s.decode('latin1'))
                  ret = len(s)
              elif name == 'fputs':                        # fputs(string, stream)
                  self.out.append(self._cstr(self._arg(0)).decode('latin1'))
                  ret = 1
              elif name in ('fputc', 'putc'):              # fputc(char, stream)
                  ret = self._arg(0) & 255
                  self.out.append(chr(ret))
              elif name == 'fwrite':                       # fwrite(buffer, size, count, stream)
                  n = min(self._arg(1) * self._arg(2), 65536)
                  self.out.append(self._rd(self._arg(0), n).decode('latin1'))
                  ret = self._arg(2)
              elif name in ('iob_func', 'acrt_iob_func'):  # the stdout/stderr handles: only ever handed back to fprintf and friends
                  ret = self.HEAP + 0x300
              else:
                  self.out.append('[hadesr.dll import "%s" not emulated]\n' % name)
              mu.reg_write(self._u[2], ret & 0xFFFFFFFF)
              retaddr = struct.unpack('<I', self._rd(esp, 4))[0]
              mu.reg_write(self._u[0], esp + 4)
              mu.reg_write(self._u[1], retaddr)

          def decode(self, ptype, src, plain):
              func = DLL_FUNCS.get(ptype)
              if func is None or func not in self.exp:
                  return None
              from unicorn import UcError
              self.out = []
              buf = self.HEAP + 0x200000
              self.mu.mem_write(buf, b'\xaa' * 16 + b'\xbf\x35' + plain + b'\0' * 512)
              esp = self.STACK + 0x1F0000
              for a in (buf, src):                 # cdecl: push right-to-left
                  esp -= 4
                  self.mu.mem_write(esp, struct.pack('<I', a))
              esp -= 4
              self.mu.mem_write(esp, struct.pack('<I', 0xDEAD0000))
              self.mu.reg_write(self._u[0], esp)
              try:
                  self.mu.emu_start(self.exp[func], 0xDEAD0000)
              except UcError as e:
                  self.out.append('[emulation stopped: %s]\n' % e)
              return ''.join(self.out)



      # ----------------------------------------------------------------------------
      # Adaptive FSK centre tracker / channelizer ("AFC")
      #   Looks ahead by `delay_s` seconds: it analyses the incoming wideband IQ for the
      #   two-tone signature of the UNNE-1B FSK signal anywhere in the band, estimates the
      #   centre of the two tones every 0.1 s (also following Doppler drift inside a burst),
      #   and mixes the delayed stream so that the centre sits at 0 Hz.  Because of the
      #   look-ahead the mixer is already on the right frequency when a burst begins, even if
      #   the Doppler shift moved by several kHz since the previous burst.
      # ----------------------------------------------------------------------------
      class FskCentreTracker(object):
          def __init__(self, fs=50000.0, delay_s=1.2, nfft=8192, hop_s=0.1, min_db=15.0,
                       spacing=(1000.0, 2400.0), persist=3, spread=250.0, window_s=0.35,
                       lead_s=0.6):
              self.fs = float(fs)
              self.nfft = int(nfft)
              self.hop = max(1, int(round(hop_s * fs)))
              self.delay = int(round(delay_s * fs))
              if self.delay < 2 * self.nfft:
                  raise ValueError('delay too short for the FFT size')
              self.min_lin = 10.0 ** (min_db / 10.0)
              self.spacing = spacing
              self.persist = int(persist)
              self.spread = float(spread)
              self.win_n = int(window_s * fs)
              self.lead_n = int(lead_s * fs)
              self.freqs = np.fft.fftshift(np.fft.fftfreq(self.nfft, 1.0 / self.fs))
              self.win = np.hanning(self.nfft)
              self.buf = np.zeros(0, dtype=np.complex64)
              self.n_in = 0                       # total input samples
              self.out_pos = 0                    # next output sample index (global)
              self.next_hop = 0
              self.raw = {}                       # hop -> (tag, centre, spacing, dB)
              self.acc_tags = []                  # accepted detections, sorted by tag
              self.acc_cent = []
              self.acc_hops = set()
              self.phase = 0.0
              self.last_c = 0.0
              self.cache = {}

          # -- detection -----------------------------------------------------------
          def _detect(self, seg):
              P = np.abs(np.fft.fftshift(np.fft.fft(seg * self.win))) ** 2
              floor = float(np.median(P)) + 1e-30
              Ps = np.convolve(P, np.ones(3) / 3.0, 'same')
              mx = np.where((Ps[1:-1] > Ps[:-2]) & (Ps[1:-1] >= Ps[2:]))[0] + 1
              mx = mx[Ps[mx] > floor * self.min_lin]
              if len(mx) < 2:
                  return None
              order = mx[np.argsort(Ps[mx])[::-1]][:12]
              best = None
              for i, p1 in enumerate(order):
                  for p2 in order[i + 1:]:
                      d = abs(self.freqs[p1] - self.freqs[p2])
                      if self.spacing[0] <= d <= self.spacing[1]:
                          lo, hi = (p1, p2) if self.freqs[p1] < self.freqs[p2] else (p2, p1)
                          score = min(Ps[lo], Ps[hi])
                          if min(Ps[lo], Ps[hi]) >= 0.1 * max(Ps[lo], Ps[hi]) and \
                                  (best is None or score > best[0]):
                              best = (score, lo, hi)
              if best is None:
                  return None
              _, lo, hi = best

              def refine(k):
                  y0, y1, y2 = np.log(Ps[k - 1] + 1e-30), np.log(Ps[k] + 1e-30), np.log(Ps[k + 1] + 1e-30)
                  den = y0 - 2 * y1 + y2
                  off = 0.5 * (y0 - y2) / den if den != 0 else 0.0
                  return self.freqs[k] + max(-1.0, min(1.0, off)) * (self.fs / self.nfft)
              f_lo, f_hi = refine(lo), refine(hi)
              return ((f_lo + f_hi) / 2.0, f_hi - f_lo,
                      10.0 * np.log10(min(Ps[lo], Ps[hi]) / floor))

          def _analyse(self):
              while self.next_hop * self.hop + self.nfft <= self.n_in:
                  h = self.next_hop
                  a = h * self.hop - self.out_base
                  if a < 0:
                      self.next_hop += 1
                      continue
                  det = self._detect(self.buf[a:a + self.nfft])
                  self.next_hop += 1
                  if det is not None:
                      self.raw[h] = (h * self.hop + self.nfft // 2,) + det
                      self._persist(h)
                  self.raw.pop(h - 50, None)

          def _persist(self, h):
              hs = [h - k for k in range(self.persist)]
              if not all(x in self.raw for x in hs):
                  return
              cs = [self.raw[x][1] for x in hs]
              if max(cs) - min(cs) > self.spread:
                  return
              for x in sorted(hs):
                  if x not in self.acc_hops:
                      self.acc_hops.add(x)
                      tag, c = self.raw[x][0], self.raw[x][1]
                      i = len(self.acc_tags)
                      while i > 0 and self.acc_tags[i - 1] > tag:
                          i -= 1
                      self.acc_tags.insert(i, tag)
                      self.acc_cent.insert(i, c)

          # -- centre as a function of time ---------------------------------------
          def _centre_for_block(self, blk):
              if blk in self.cache:
                  return self.cache[blk]
              tmid = (blk + 0.5) * self.hop
              tags = np.asarray(self.acc_tags)
              cents = np.asarray(self.acc_cent)
              c = None
              if len(tags):
                  near = np.abs(tags - tmid) <= self.win_n
                  if near.any():
                      c = float(np.median(cents[near]))
                  else:
                      fut = np.where((tags > tmid) & (tags <= tmid + self.lead_n))[0]
                      if len(fut):
                          c = float(cents[fut[0]])
                      else:
                          past = np.where(tags < tmid)[0]
                          if len(past):
                              c = float(cents[past[-1]])
              if c is None:
                  c = self.last_c
              self.last_c = c
              self.cache[blk] = c
              for k in [k for k in self.cache if k < blk - 4]:
                  del self.cache[k]
              return c

          # -- streaming interface -------------------------------------------------
          @property
          def out_base(self):
              return self._out_base

          _out_base = 0

          def push(self, x, flush=False):
              x = np.asarray(x, dtype=np.complex64)
              self.buf = np.concatenate([self.buf, x])
              self.n_in += len(x)
              self._analyse()
              end = self.n_in if flush else self.n_in - self.delay
              if end <= self.out_pos:
                  return np.zeros(0, np.complex64), np.zeros(0, np.float32)
              ys, cs = [], []
              pos = self.out_pos
              while pos < end:
                  blk = pos // self.hop
                  seg_end = min(end, (blk + 1) * self.hop)
                  c = self._centre_for_block(blk)
                  seg = self.buf[pos - self._out_base:seg_end - self._out_base]
                  k = np.arange(len(seg))
                  ph = self.phase + 2.0 * np.pi * c / self.fs * k
                  ys.append((seg * np.exp(-1j * ph)).astype(np.complex64))
                  cs.append(np.full(len(seg), c, np.float32))
                  self.phase = (self.phase + 2.0 * np.pi * c / self.fs * len(seg)) % (2 * np.pi)
                  pos = seg_end
              self.out_pos = pos
              drop = self.out_pos - self._out_base
              if drop > 0:
                  self.buf = self.buf[drop:]
                  self._out_base += drop
              return np.concatenate(ys), np.concatenate(cs)

          def flush(self):
              return self.push(np.zeros(0, np.complex64), flush=True)


      # ----------------------------------------------------------------------------
      # Streaming demodulator / deframer
      # ----------------------------------------------------------------------------
      class Unne1bDeframer(object):
          """Feed it complex baseband centred on the FSK signal (|offset| < ~1.5 kHz)
          and band-limited to about +-2 kHz, sample rate fs (e.g. 10 kHz)."""

          def __init__(self, fs=10000.0, baud=200.0, kp=0.15, ki=0.002,
                       max_flips=3, flip_candidates=16, clip_hz=2500.0, emit_unverified=False):
              self.fs = float(fs)
              self.baud = float(baud)
              self.emit_unverified = bool(emit_unverified)
              self.sps0 = self.fs / float(baud)
              self.T = self.sps0
              self.kp, self.ki = kp, ki
              self.max_flips, self.flip_candidates = max_flips, flip_candidates
              self.clip = clip_hz
              self.last = 1 + 0j
              self.ma_len = max(8, int(round(24 * self.sps0)))
              self.sm_len = max(1, int(round(self.sps0 / 6.0)))
              self.tail_ma = np.zeros(0)
              self.tail_sm = np.zeros(0)
              self.tail_fa = np.zeros(0)
              self.prev_dd = 0.0
              self.n = 0                         # samples consumed so far
              self.buf = np.zeros(0, dtype=np.float32)
              self.xbuf = np.zeros(0, dtype=np.complex64)   # complex baseband, same indexing
              self.fbuf = np.zeros(0, dtype=np.float32)     # smoothed absolute frequency (Hz)
              self.buf0 = 0                      # global index of buf[0]
              self.fm = None                     # tracked mark   (lower tone) frequency, Hz
              self.fs_ = None                    # tracked space  (higher tone) frequency, Hz
              self.nf = None                     # running noise-floor estimate (|x|^2 per sample)
              self.nf_min = float('inf')         # lowest noise floor seen
              self.nseed = []                    # first noise-power samples used to seed nf
              self.fm0 = self.fs0 = None         # first learned tone frequencies (for clamping)
              self.nafc = 0                      # confident symbols seen (AFC gain schedule)
              self.lm, self.ls, self.nlearn = [], [], 0   # tone-learning scratch
              self.span = 450.0                  # tone search half-width, Hz
              self.fstep = 25.0
              self.edges = []
              self.t = None
              self.quiet = 99                    # symbols since the signal was last strong (burst-start detection)
              self.alt = 0                       # length of the current run of alternating bits (training pattern)
              self.T_ref = self.sps0             # symbol period learned from the last training pattern
              self.bits = []
              self.soft = []
              self.scan = 0
              self.nframes = 0
              self.dropped = 0                   # bits trimmed from the front of self.bits so far
              self.failed = set()                # (global sync position, layout) already tried and rejected

          @staticmethod
          def _causal_ma(x, L, tail):
              hist = np.concatenate([tail, x]).astype(np.float64)
              cs = np.cumsum(hist)
              p = np.arange(len(tail), len(hist))
              s = np.maximum(p - L + 1, 0)
              prev = np.where(s > 0, cs[np.maximum(s - 1, 0)], 0.0)
              y = (cs[p] - prev) / (p - s + 1)
              new_tail = hist[-(L - 1):] if L > 1 else np.zeros(0)
              return y, new_tail

          def push(self, x):
              """x: complex samples. Returns (demod_float32_same_length, [frames])."""
              x = np.asarray(x, dtype=np.complex64)
              if len(x) == 0:
                  return np.zeros(0, np.float32), []
              xx = np.concatenate([[self.last], x])
              disc = np.angle(xx[1:] * np.conj(xx[:-1])) * self.fs / (2 * np.pi)
              self.last = x[-1]
              disc = np.clip(disc, -self.clip, self.clip)
              mean, self.tail_ma = self._causal_ma(disc, self.ma_len, self.tail_ma)
              dd, self.tail_sm = self._causal_ma(disc - mean, self.sm_len, self.tail_sm)
              dd32 = dd.astype(np.float32)
              fabs, self.tail_fa = self._causal_ma(disc, self.sm_len, self.tail_fa)

              # zero crossings (sub-sample)
              s = np.concatenate([[self.prev_dd], dd])
              idx = np.where(np.signbit(s[:-1]) != np.signbit(s[1:]))[0]
              if len(idx):
                  frac = -s[idx] / (s[idx + 1] - s[idx])
                  self.edges.extend((self.n - 1 + idx + frac).tolist())
              self.prev_dd = float(dd[-1])
              self.n += len(x)
              self.buf = np.concatenate([self.buf, dd32])
              self.xbuf = np.concatenate([self.xbuf, x])
              self.fbuf = np.concatenate([self.fbuf, fabs.astype(np.float32)])

              self._dpll()
              frames = self._scan_frames()
              return dd32, frames

          def _decide(self, t, T, a, b, m, p, strong):
              """Per-symbol decision. Non-coherent tone-energy detector (about 10 dB better than
              the FM discriminator near the noise floor) once both tones have been learned."""
              a0 = int(round(t - T / 2)) - self.buf0
              b0 = a0 + int(round(T))
              hard = 1 if m < 0 else 0
              if self.fm is None or self.fs_ is None:
                  if strong and abs(m) > 300.0:
                      self.nlearn += 1
                      if self.nlearn > 4:                     # skip the burst-onset transient
                          q = max(1, (b - a) // 4)
                          fa = float(self.fbuf[a + q:b - q].mean())   # middle half: avoids transitions
                          (self.lm if hard else self.ls).append(fa)
                          if len(self.lm) >= 6 and len(self.ls) >= 6:
                              fm = float(np.median(self.lm[-8:]))
                              fs_ = float(np.median(self.ls[-8:]))
                              if fs_ - fm >= 600.0:
                                  self.fm, self.fs_ = fm, fs_
                                  self.fm0, self.fs0 = fm, fs_
                              else:                           # implausible: start over
                                  self.lm, self.ls, self.nlearn = [], [], 0
                  return hard, -m
              if a0 < 0 or b0 > len(self.xbuf):
                  return hard, -m
              seg = self.xbuf[a0:b0]
              k = np.arange(len(seg))
              grid = np.arange(-self.span, self.span + 1, self.fstep)

              def best(fc):
                  fr = fc + grid
                  E = np.abs(np.exp(-2j * np.pi * np.outer(fr, k) / self.fs) @ seg) ** 2
                  i = int(np.argmax(E))
                  return E[i], fr[i]
              em, fm_new = best(self.fm)
              es, fs_new = best(self.fs_)
              z = (em - es) / (em + es + 1e-20)             # >0 -> mark (bit 1)
              bit = 1 if z > 0 else 0
              if strong and abs(z) > 0.5:                   # AFC, only on confident, strong symbols
                  g = 0.3 if self.nafc < 40 else 0.1         # converge fast, then track slowly
                  self.nafc += 1
                  if bit:
                      self.fm = float(np.clip((1 - g) * self.fm + g * fm_new,
                                              self.fm0 - 700, self.fm0 + 700))
                  else:
                      self.fs_ = float(np.clip((1 - g) * self.fs_ + g * fs_new,
                                               self.fs0 - 700, self.fs0 + 700))
              return bit, z * 1000.0

          def _dpll(self):
              if self.t is None:
                  self.t = self.buf0 + self.T
              T, t = self.T, self.t
              lo, hi = self.sps0 * 0.97, self.sps0 * 1.03
              end = self.buf0 + len(self.buf)
              while t + 0.75 * T + 2 < end:
                  a = int(t - T / 4) - self.buf0
                  b = int(t + T / 4) - self.buf0 + 1
                  if a < 0:                     # data already trimmed: resync
                      t = self.buf0 + T
                      continue
                  m = float(self.buf[a:b].mean())
                  xa = int(round(t - T / 2)) - self.buf0
                  xb = xa + int(round(T))
                  if xa >= 0 and xb <= len(self.xbuf):
                      p = float(np.mean(np.abs(self.xbuf[xa:xb]) ** 2))
                  else:
                      p = 0.0
                  if p > 1e-14:                          # ignore the silent (zero) pre-fill of the tracker
                      if self.nf is None:
                          self.nseed.append(p)
                          if len(self.nseed) >= 40:      # seed the noise floor robustly
                              self.nf = 0.7 * float(np.median(self.nseed))
                              self.nf_min = self.nf
                      elif p < self.nf:
                          self.nf = p
                          self.nf_min = min(self.nf_min, p)
                      else:                              # rises only slowly, but never far above the lowest floor seen (a long continuous burst must stay "strong")
                          self.nf = min(self.nf * 1.0015, 50.0 * self.nf_min)
                  strong = self.nf is not None and p > 6.0 * self.nf
                  if strong:
                      if self.quiet >= 24:             # a new burst: the bit rate is the nominal one again
                          T = self.T_ref = self.sps0
                      self.quiet = 0
                  else:
                      self.quiet += 1
                  bit, soft = self._decide(t, T, a, b, m, p, strong)
                  self.alt = self.alt + 1 if self.bits and bit != self.bits[-1] else 0
                  self.bits.append(bit)
                  self.soft.append(soft)
                  tb = t + T / 2
                  j = bisect_left(self.edges, tb - T / 2)       # +-T/2 capture range: no dead zone
                  if strong and j < len(self.edges) and self.edges[j] < tb + T / 2:
                      err = self.edges[j] - tb
                      t += self.kp * err
                      if self.alt >= 8:        # the rate is learned from the training pattern at a high gain ...
                          T = min(hi, max(lo, T + 5.0 * self.ki * err))
                          self.T_ref = T
                      else:                    # ... and from the data only gently and within +-0.5 % of that (unscrambled data biases the edges)
                          r = self.T_ref
                          T = min(r * 1.005, max(r * 0.995, T + 0.25 * self.ki * err))
                  t += T
              self.T, self.t = T, t
              # trim buffers
              keep_from = int(t - 2 * T)
              drop = keep_from - self.buf0
              if drop > 0:
                  self.buf = self.buf[drop:]
                  self.xbuf = self.xbuf[drop:]
                  self.fbuf = self.fbuf[drop:]
                  self.buf0 += drop
              k = bisect_left(self.edges, keep_from)
              if k:
                  del self.edges[:k]

          @staticmethod
          def _checker(kind, crc_from):
              """Returns (check(raw) -> bool, plain_of(raw)) for a layout.  `raw` = the bytes after the sync word."""
              if kind == 'ssdv':                                   # HADES-SA image packet: no CRC16, SSDV's own CRC32
                  def plain_of(raw):
                      return ssdv_plain(raw) or raw[1:]            # unverified: leave as received

                  def check(raw):
                      return ssdv_plain(raw) is not None
                  return check, plain_of

              def check(raw):
                  return crc16_ccitt_false(raw[crc_from:-2]) == (raw[-2] << 8 | raw[-1])

              def plain_of(raw):
                  return raw[crc_from:crc_from + 1] + descramble(raw[crc_from + 1:-2])
              return check, plain_of

          @classmethod
          def _attempt(cls, rawbits, softs, crc_from, nflips, flip_candidates, kind='crc16'):
              """Try to make the frame pass its check by flipping exactly `nflips` of the least certain bits (0 = as
              received).  Returns (plain, raw, flips) on success, else None.  `plain` = type/address byte + descrambled data."""
              check, plain_of = cls._checker(kind, crc_from)
              if nflips == 0:
                  raw = bits_to_bytes(rawbits)
                  return (plain_of(raw), raw, []) if check(raw) else None
              lo = 8 * (crc_from + 1)
              sv = np.abs(np.array(softs[lo:]))
              order = (np.argsort(sv)[:flip_candidates] + lo).tolist()
              for comb in combinations(order, nflips):
                  bb = list(rawbits)
                  for c in comb:
                      bb[c] ^= 1
                  r2 = bits_to_bytes(bb)
                  if check(r2):
                      return plain_of(r2), r2, list(comb)
              return None

          @staticmethod
          def _has_sclock(src, ptype):
              if src in (3, 5):                                   # HADES-SA / HADES-L
                  return ptype in ((1, 2, 3, 4, 5, 14, 15) if src == 5 else (1, 2, 3, 4, 5, 14))
              return ptype in (1, 2, 3, 4, 5, 10, 14)             # UNNE-1B family

          def _frame_dict(self, framing, plain, raw, flips, crc_ok):
              ptype, src = plain[0] >> 4, plain[0] & 0x0F
              fr = {'type': ptype, 'src': src, 'src_name': SOURCES.get(src, 'unknown'),
                    'type_name': type_name(src, ptype), 'framing': framing, 'baud': int(self.baud),
                    'raw': raw.hex(), 'plain': plain.hex(), 'flips': flips, 'crc_ok': crc_ok,
                    'sclock': (struct.unpack('<I', plain[1:5])[0] if self._has_sclock(src, ptype) and len(plain) >= 5 else
                               (struct.unpack('<I', plain[2:6])[0] if (src, ptype) == (5, 7) and len(plain) >= 6 else None))}
              if framing == 'sized':
                  fr['size'] = raw[0]
              return fr

          def _byte_at(self, i):
              return int(''.join(map(str, self.bits[i:i + 8])), 2)

          def _scan_frames(self):
              """Find frames after each 0xBF35 sync word.  Three layouts are recognised:
                legacy   type/addr, data, CRC                    (UNNE-1B telemetry; length from the type)
                sized    size, type/addr, data, CRC              (HADES-SA, HADES-L; length from the size byte)
                voice    0x25, type/addr (type 15 or 11), number, 35 bytes   (CODEC2; no CRC)
              Candidates are first checked exactly; bit repair is only tried when every candidate's bits have arrived, and
              with the fewest flips first, so a true frame beats a chance CRC match of a wrong layout."""
              frames = []
              while True:
                  s = ''.join(map(str, self.bits[self.scan:]))
                  j = s.find(SYNC_BITS)
                  if j < 0:
                      # keep a tail so a sync split across pushes is still found
                      self.scan = max(self.scan, len(self.bits) - len(SYNC_BITS) + 1)
                      break
                  a = self.scan + j
                  if len(self.bits) < a + 32:
                      self.scan = a
                      break
                  b0, b1 = self._byte_at(a + 16), self._byte_at(a + 24)
                  if b0 == VOICE_SIZE_BYTE and (b1 >> 4) in VOICE_TYPES:        # CODEC2 voice: exclusive, no CRC
                      nbits = 8 * (1 + VOICE_SIZE_BYTE)
                      if len(self.bits) < a + 16 + nbits:
                          self.scan = a
                          break
                      payload = bits_to_bytes(self.bits[a + 40:a + 16 + nbits])
                      self.nframes += 1
                      frames.append({'type': b1 >> 4, 'src': b1 & 15, 'src_name': SOURCES.get(b1 & 15, 'unknown'),
                                     'type_name': type_name(b1 & 15, b1 >> 4), 'framing': 'sized', 'voice': True,
                                     'baud': int(self.baud), 'number': self._byte_at(a + 32), 'payload': payload.hex(),
                                     'raw': payload.hex(), 'plain': payload.hex(), 'flips': [], 'crc_ok': None,
                                     'sclock': None, 'nocrc': True})
                      self.scan = a + 16 + nbits
                      continue
                  if b0 in PN9_SIZES and (b1 >> 4) == 13 and (b1 & 15) in SOURCES:       # PN9 link test: no CRC
                      nbits = 8 * (1 + b0)
                      if len(self.bits) < a + 16 + nbits:
                          self.scan = a
                          break
                      raw = bits_to_bytes(self.bits[a + 16:a + 16 + nbits])
                      plain = raw[1:]                              # the PN9 pattern goes out as is (no scrambler): verified on air
                      self.nframes += 1
                      frames.append(self._frame_dict('sized', plain, raw, [], None))
                      self.scan = a + 16 + nbits
                      continue
                  cands = []
                  if (b0 >> 4) in TOTAL_BYTES and (b0 & 15) in LEGACY_SOURCES:
                      cands.append(('legacy', 8 * (TOTAL_BYTES[b0 >> 4] - PRE_BYTES), 0))
                  if b0 == SSDV_SIZE_BYTE and (b1 >> 4) == 10 and (b1 & 15) in SOURCES:           # SSDV image packet
                      cands.append(('ssdv', 8 * (1 + b0), 1))
                  elif 3 <= b0 <= 255 and (b1 >> 4) >= 1 and (b1 & 15) in SOURCES:
                      cands.append(('sized', 8 * (1 + b0), 1))
                  gidx = self.dropped + a
                  cands = [c for c in cands if (gidx, c[0]) not in self.failed]
                  cands.sort(key=lambda c: c[1])
                  have = [c for c in cands if len(self.bits) >= a + 16 + c[1]]
                  pending = len(have) < len(cands)
                  hit = None
                  for kind, nbits, crc_from in have:                           # 1. exact CRC, shortest layout first
                      r = self._attempt(self.bits[a + 16:a + 16 + nbits], None, crc_from, 0, 0, kind)
                      if r:
                          hit = (kind, nbits) + r
                          break
                  if hit is None and pending:
                      self.scan = a                                            # wait for the longer layouts' bits
                      break
                  if hit is None:                                              # 1b. SSDV: Reed-Solomon repair of damaged bytes
                      for kind, nbits, crc_from in have:
                          if kind == 'ssdv':
                              raw = bits_to_bytes(self.bits[a + 16:a + 16 + nbits])
                              fixed = ssdv_repair(raw)
                              if fixed:
                                  hit = (kind, nbits, fixed[0], raw, [])
                                  break
                  if hit is None and self.max_flips > 0:                       # 2. bit repair, fewest flips first
                      for nf in range(1, self.max_flips + 1):
                          for kind, nbits, crc_from in have:
                              r = self._attempt(self.bits[a + 16:a + 16 + nbits], self.soft[a + 16:a + 16 + nbits],
                                                crc_from, nf, self.flip_candidates, kind)
                              if r:
                                  hit = (kind, nbits) + r
                                  break
                          if hit:
                              break
                  if hit is not None:
                      kind, nbits, plain, raw, flips = hit
                      self.nframes += 1
                      frames.append(self._frame_dict('sized' if kind == 'ssdv' else kind, plain, raw, flips, True))
                      self.scan = a + 16 + nbits
                      continue
                  for kind, nbits, crc_from in have:
                      self.failed.add((gidx, kind))
                  sized = [c for c in have if c[0] == 'sized']
                  if self.emit_unverified and sized:                           # for exploring new satellites / packet types
                      nbits = sized[0][1]
                      raw = bits_to_bytes(self.bits[a + 16:a + 16 + nbits])
                      plain = raw[1:2] + descramble(raw[2:-2])
                      self.nframes += 1
                      frames.append(self._frame_dict('sized', plain, raw, [], False))
                      self.scan = a + 16 + nbits
                      continue
                  self.scan = a + 1
              # bound memory
              if len(self.bits) > 8192:
                  drop = len(self.bits) - 4096
                  del self.bits[:drop]
                  del self.soft[:drop]
                  self.dropped += drop
                  self.scan = max(0, self.scan - drop)
                  self.failed = {k for k in self.failed if k[0] >= self.dropped}
              return frames

      class MultiBaudDeframer(object):
          """Runs one Unne1bDeframer per baud rate on the same stream, because HADES-SA alternates between 800 and 200 baud
          (and HADES-L can be switched by telecommand).  A frame is reported by whichever rate it is received at."""

          def __init__(self, fs=10000.0, bauds=(200.0,), **kw):
              self.deframers = [Unne1bDeframer(fs=fs, baud=b, **kw) for b in bauds]

          @property
          def nframes(self):
              return sum(d.nframes for d in self.deframers)

          def push(self, x):
              """Returns (demodulated float stream of the first baud rate, frames from all rates)."""
              first, frames = None, []
              for i, d in enumerate(self.deframers):
                  dd, fr = d.push(x)
                  if i == 0:
                      first = dd
                  frames.extend(fr)
              return first, frames


      def parse_bauds(value):
          """'auto' -> (200, 800); '800' -> (800,); '200,800' -> (200, 800); a number or a list of numbers also works."""
          if isinstance(value, (int, float)):
              return (float(value),)
          if isinstance(value, (list, tuple)):
              return tuple(float(v) for v in value)
          v = str(value).strip().lower()
          if v in ('', 'auto'):
              return (200.0, 800.0)
          out = tuple(float(t) for t in v.replace(' ', '').split(',') if t)
          if not out or any(b <= 0 for b in out):
              raise ValueError('baud must be "auto", a number, or a comma separated list (got %r)' % (value,))
          return out


      def format_frame(fr, dll=None):
          ptype, src = fr['type'], fr['src']
          name = fr.get('type_name') or type_name(src, ptype)
          # UNNE-1B keeps its original header text; other satellites are named by their source address
          if src == 0xC:
              lead = 'UNNE-1B packet type %d (%s)' % (ptype, name)
              tail = ' from %s' % fr['src_name']
          else:
              lead = '%s packet type %d (%s)' % (fr['src_name'], ptype, name)
              tail = ''
          if fr.get('voice'):
              return ('=== %s frame #%d%s [no CRC in this packet type] ===\n'
                      'payload (35 bytes, 280 bits): %s' % (lead.replace('(%s)' % name, '(%s)' % name), fr['number'],
                                                            tail, fr['payload']))
          crc = fr.get('crc_ok', True)
          status = 'CRC OK' if crc else ('no CRC in this packet type' if crc is None else 'CRC FAIL - unverified')
          if fr['flips']:
              status += ', corrected bits %s' % fr['flips']
          lines = ['=== %s%s  [%s] ===' % (lead, tail, status)]
          if fr.get('framing') == 'sized' or fr.get('baud', 200) != 200:
              lines.append('link: %s baud%s' % (fr.get('baud', 200),
                                                (', length byte %d' % fr['size']) if fr.get('size') is not None else ''))
          if fr['sclock'] is not None:
              sc = fr['sclock']
              lines.append('sclock: %d s  (%dd %02d:%02d:%02d since boot)' % (
                  sc, sc // 86400, sc % 86400 // 3600, sc % 3600 // 60, sc % 60))
          text = None
          dll_ok = src in DLL_SATELLITES and fr.get('crc_ok', True) and fr.get('framing', 'legacy') == 'legacy'
          if dll is not None and dll_ok:
              try:
                  text = dll.decode(ptype, src, bytes.fromhex(fr['plain']))
              except Exception as e:                       # noqa
                  text = '[DLL decode failed: %s]' % e
          if not text and crc is not False:
              text = _native_text(fr)                      # HADES-SA / HADES-L: decoded here, no DLL needed
          if text:
              lines.append(text.rstrip())
          else:
              scrambled = not (fr.get('framing') == 'sized' and ptype in (10, 13))
              lines.append('data (%s): %s' % ('descrambled' if scrambled else 'as received, not scrambled', fr['plain'][2:]))
              lines.append('whole frame (type/address byte first, no CRC): %s' % ' '.join(
                  fr['plain'][i:i + 2] for i in range(0, len(fr['plain']), 2)).upper())
              if dll_ok:
                  lines.append("(the frame is decoded and CRC-checked; the field names (voltages, temperatures ...) need AMSAT-EA's decoder: "
                               'pass --dll hadesr.dll)')
              elif crc is False:
                  lines.append('(CRC failed: not decoded)')
              else:
                  lines.append('(field-by-field decoding for %s is not implemented yet - raw bytes shown)' % fr['src_name'])
          return '\n'.join(lines)


      def _native_text(fr):
          """The labelled text of the native decoders for HADES-SA / HADES-L frames (None for other satellites or packet types),
          without the time line, which is not known here."""
          try:
              try:
                  decode, native, Context = decode_frame, NATIVE_SOURCES, Ctx          # noqa: F821  genesis.py shares the namespace
              except NameError:
                  from .genesis import decode_frame as decode, NATIVE_SOURCES as native, Ctx as Context
              if fr['src'] not in native:
                  return None
              res = decode(fr['type'], fr['src'], bytes.fromhex(fr['plain']), Context(0))
          except Exception:                                # noqa: genesis not available, or a frame the decoders cannot handle
              return None
          if res is None or not res[0]:
              return None
          body = res[0].split('\n', 1)[1] if res[0].startswith('***') else res[0]
          out = []
          for line in body.split('\n'):
              if 'Data matching rate' in line and line[:8].isdigit():        # the PN9 line starts with the (unknown here) time
                  line = line[line.index('Data matching rate'):]
              out.append(line)
          return '\n'.join(out).rstrip('\n')
      # HADESx Decoder  -  https://github.com/N6RFM/HADESx-Decoder
      # Authors: N6RFM, with Claude (an AI assistant made by Anthropic).
      # Licence: MIT (see LICENSE).
      # A Python port of the decoding and file-writing logic of AMSAT-EA's HADES-SA decoder, (c) AMSAT EA, CC BY 4.0 (NOTICE.md, section 7).
      """Per-type decoded output for the GENESIS / HADES family: text (.tlm), data (.dat) and binary (.bin) files.

      This is a Python port of the decoding and file-writing logic of AMSAT-EA's open-source HADES-SA decoder
      ("HADES-SA (SpinnyONE) Satellite Telemetry Decoder", byte_version/main.c, (c) AMSAT EA, CC BY 4.0,
      https://github.com/AMSAT-EA/HADES-SA_SpinnyONE).  The folder it produces looks and behaves like the one written by
      AMSAT-EA's Windows tool (UZ7HO SoundModem + KISSGENESIS + hadessa.dll):

          sat_03_type_01.tlm                      latest packet of that type, labelled text (overwritten)
          sat_03_type_01.dat                      one line per packet: epoch, 0, satellite clock, values ...  (appended)
          20260401-142010_sat_03_type_01.tlm      the same text, one file per reception
          sat_03_type_14_00.tlm / .dat            time series: one pair per variable
          sat_03_type_11_codec2_frame_005.bin     CODEC2 voice frame (40 bytes, ready for c2dec), rewritten per frame number
          sat_03_type_10_ssdv_img_218_packet_0012.bin   one 256-byte SSDV packet per image and packet number

      The decoders take the frame as AMSAT-EA's tool does: `rx` = type/address byte, data, and the 2 CRC bytes where the packet
      has them (already descrambled and CRC checked).  The structure layouts, scalings and printf formats are the original's;
      tests/test_genesis.py compares the output with that program's output on the same frames.
      """
      import datetime
      import math
      import os
      import re
      import struct
      import time

      # ---- C-like helpers ---------------------------------------------------------------------------------------------


      def s32(x):
          x &= 0xFFFFFFFF
          return x - (1 << 32) if x & 0x80000000 else x


      def s16(x):
          x &= 0xFFFF
          return x - (1 << 16) if x & 0x8000 else x


      def u16(rx, i):
          return rx[i] | (rx[i + 1] << 8)


      def u32(rx, i):
          return rx[i] | (rx[i + 1] << 8) | (rx[i + 2] << 16) | (rx[i + 3] << 24)


      def be16(rx, i):
          return (rx[i] << 8) | rx[i + 1]


      def be32(rx, i):
          return (rx[i] << 24) | (rx[i + 1] << 16) | (rx[i + 2] << 8) | rx[i + 3]


      def cdiv(a, b):
          """C integer division (truncates toward zero); the original would crash on a zero divisor, we return 0."""
          if b == 0:
              return 0
          q = abs(a) // abs(b)
          return q if (a >= 0) == (b >= 0) else -q


      def cf(v):
          """printf("%f") as the Windows tool (MinGW) prints it: NaN is "nan" whatever its sign (glibc would print "-nan")."""
          if v != v:
              return 'nan'
          return '%f' % v


      # ---- tables from the original --------------------------------------------------------------------------------------

      SAT_DESC = ['Unknown', 'Unknown', 'HADES-ICM', 'SpinnyONE HADES-SA', 'Unknown', 'HADES-L', 'Unknown', 'Unknown',
                  'Unknown', 'GENESIS-M', 'Unknown', 'MARIA-G', 'UNNE-1B', 'HADES-R']       # index = source address
      # (the original has "Unknown" at 5; HADES-L = 5 is this project's assumption, see docs/satellites.md)

      # bytes in a frame of each packet type as the original takes it: type/address .. last byte (CRC included where present)
      BYTES_UTILES = [2, 31, 17, 41, 35, 27, 135, 45, 31, 123, 251, 37, 64, 249, 38, 73]            # HADES-SA (and the default)
      # HADES-L (hadesl.dll): type 7 is the 23-byte Lofith packet, type 15 the 101-byte ICM message, type 6 is not used
      BYTES_UTILES_L = [2, 31, 17, 41, 35, 27, 1, 23, 31, 123, 251, 37, 64, 249, 38, 101]
      SIZES_BY_SOURCE = {3: BYTES_UTILES, 5: BYTES_UTILES_L}


      def frame_size(source, ptype):
          table = SIZES_BY_SOURCE.get(source, BYTES_UTILES)
          return table[ptype] if ptype < len(table) else None

      PACKET_DESC = ['-', 'pwr', 'tmp', 'status', 'pwr_ranges', 'tmp_ranges', 'unknown', 'unknown', 'antenna',
                     'extended power - ina219', 'SSDV', 'CODEC2 voice', 'ephemeris', 'PN9 random data', 'time series', 'BBS']

      INE_NAMES = ['SPA ', 'SPB ', 'SPC ', 'SPD ', 'SUN ', 'BAT ', 'BATP', 'BATN', 'CPU ', 'PL  ']
      TIME_SERIES_DESC = ['signal_peak', 'moda_noise', 'vbat1 - bat voltage read in EPS.ADC', 'tcpu', 'tpb',
                          'tpa-tpd mean_temp']
      TIME_SERIES_DESC_L = TIME_SERIES_DESC[:4] + ['tpc'] + TIME_SERIES_DESC[5:]       # HADES-L: variable 4 is temperature of panel C

      VOICE_XOR_KEY = bytes([
          0xed, 0x15, 0xd5, 0x3b, 0x34, 0x70, 0xe0, 0xfd, 0xed, 0x83, 0x90, 0xdb, 0xaa, 0x2e, 0x25, 0xd6, 0x5e, 0x81, 0x41,
          0x86, 0xbd, 0x67, 0x79, 0x5d, 0x70, 0xa1, 0x13, 0xce, 0x50, 0x0c, 0x19, 0xca, 0xfb, 0x44, 0x0d])

      # PN9 pseudo-random test pattern (AMSAT-EA pn9.c): what a PN9 link-test packet should contain
      PN9_RAW_DATA = bytes.fromhex(
          'B94826747DE0FF87B859B7A1CC24575E218694B8A55FD8AFF6D8C907EF5C9291'
          'D5B1C4A8D9F3C5B94826747DE0FF87DC064C38479D9D2628A332CE995DE997B0'
          'D5390C42011191D5B1C4A8D9F3C530BA48411E1C92D9F54D32D4775FBB64FDA4'
          '9BF2D4289D97B0D5390C4201117FB448744BBD8E23F3036C1EABCF4D71A2FE96'
          '298C066564FDA49BF2D4289D3A7ABB8343FB61384BDD56763BDEA25A0DDB582E'
          'F8F34D71A2FE96298C06656D546563BD122861CFC8680037D21325CE0774F528'
          '155F5A0DDB582EF8F34DD3F79B3A26B707325CCB55C150EEC5DC2CDBD0E6122B'
          'AF25CE0774F528155FDF5549167C2FDE439F49F000F45071')


      def source_desc(sat_id):
          return SAT_DESC[sat_id] if sat_id <= 13 else 'Unknown'


      def reset_cause_name(v):
          names = {0: 'Unknown', 1: 'Low Power Reset', 2: 'Window Watchdog reset', 3: 'Independent watchdog reset',
                   4: 'Software reset', 5: 'Power-on reset (POR) / Power-down reset (PDR)', 6: 'External reset pin reset',
                   7: 'Brownout reset (BOR)'}
          return names.get(v, 'TBD')


      def battery_status(v):
          return {0: 'Fully charged (3925 mV or higher) - All transmissions high power',
                  1: 'High charge (Between 3800 mV and 3925 mV)',
                  2: 'Charged (Between 3550 mV and 3800 mV) - Transmissions in low power',
                  3: 'Low charge (Between 3300 mV and 3550 mV) - Limited transmissions and in low power',
                  4: 'Very low charge (Between 3200 mV and 3300 mV) - Limited transmissions and in low power',
                  5: 'Extremely low charge (Between 2500 mV and 3200 mV) - Limited transmissions and in  low power',
                  6: 'Battery damaged (Below 2500 mV) - Battery disconnected'}.get(v, 'Unknown')


      def transponder_mode(v, hades_l=False):
          return {0: '         Disabled', 1: '         Enabled in USB->FM mode' if hades_l else '         Enabled in FM mode',
                  2: '         Enabled in FSK regenerative mode'}.get(v, '         Unknown')


      # ---- overflying (zones) -------------------------------------------------------------------------------------------

      _ZONES = [(54, -4, 7), (42, -4, 6), (48, 16, 12), (64, 18, 7), (36, 139, 11), (10, 115, 23), (27, 98, 27), (32, 61, 23),
                (24, 44, 12), (60, 151, 19), (62, 103, 19), (57, 53, 17), (-21, 80, 35), (-50, 40, 20), (-22, 134, 26),
                (0, 17, 38), (-40, -14, 27), (-48, -39, 18), (33, -37, 23), (71, -37, 12), (-8, -59, 24), (-40, -65, 19),
                (16, -88, 17), (47, -97, 30), (63, -151, 8), (72, -98, 10), (-90, 0, 22), (17, -173, 47), (-25, -128, 47),
                (-49, 142, 28), (-38, -165, 34), (90, 140, 10), (90, 60, 8), (90, 168, 8)]
      _COUNTRIES = ['United Kingdom', 'Europe', 'Europe', 'Europe', 'Japan', 'Asia', 'Asia', 'Asia', 'Saudi Arabia', 'Russia',
                    'Russia', 'Russia', 'the Indian Ocean', 'the Indian Ocean', 'Oceania', 'Africa', 'the Atlantic Ocean',
                    'the Atlantic Ocean', 'the Atlantic Ocean', 'Greenland', 'South America', 'South America',
                    'Central America', 'North America', 'North America', 'North America', 'Antartica', 'the Pacific Ocean',
                    'the Pacific Ocean', 'the Pacific Ocean', 'the Pacific Ocean', 'the Artic Ocean', 'the Artic Ocean',
                    'the Artic Ocean']
      _PI = 3.1415926535898


      def overflying(lat, lon):
          for (latc, lonc, rc), name in zip(_ZONES, _COUNTRIES):
              rc_km = rc * (_PI / 180) * 6371
              dlat = (lat - latc) * (_PI / 180) / 2.0
              dlon = (lon - lonc) * (_PI / 180) / 2.0
              a = math.sin(dlat) * math.sin(dlat) + math.cos(latc * (_PI / 180)) * math.cos(lat * (_PI / 180)) * \
                  math.sin(dlon) * math.sin(dlon)
              c = 2.0 * math.atan2(math.sqrt(a), math.sqrt(1.0 - a))
              if 6371 * c <= rc_km:
                  return 'Flying over %s' % name
          return 'The overflown area is not found in the database'


      # ---- decoders: each returns (tlm text, dat bytes) -------------------------------------------------------------------


      class Ctx(object):
          """Time context for one reception: `t` = epoch seconds (UTC), `utc` = label the time as UTC instead of local."""

          def __init__(self, t, utc=True):
              self.t = int(t)
              self.utc = utc
              d = datetime.datetime.fromtimestamp(self.t, datetime.timezone.utc if utc else None)
              self.d = d
              self.fecha = '%d%02d%02d-%02d:%02d:%02d' % (d.year, d.month, d.day, d.hour, d.minute, d.second)
              self.fecha_fichero = '%d%02d%02d-%02d%02d%02d' % (d.year, d.month, d.day, d.hour, d.minute, d.second)
              self.zone = 'UTC time' if utc else 'local time'


      def _dhms(sec):
          return sec // 86400, (sec % 86400) // 3600, (sec % 3600) // 60, sec % 60


      def _header(ctx, title):
          return '*** %s received on %s %s ***\n' % (title, ctx.zone, ctx.fecha)


      def _sclock_line(label, sclock, tail='seconds (%d days and %02d:%02d:%02d hh:mm:ss)'):
          d, h, m, s = _dhms(sclock)
          return '%s: %d ' % (label, s32(sclock)) + tail % (d, h, m, s) + '\n'


      def decode_power(rx, sat, ctx):
          sclock = u32(rx, 1)
          spa, spb, spc, spd = rx[5], rx[6], rx[7], rx[8]
          spi = u16(rx, 9)
          w_vbus_vbat_hi, w_vbat_lo_vcpu_hi, w_vcpu_lo_vbus2 = u16(rx, 11), u16(rx, 13), u16(rx, 15)
          w_vbus3_vbat2_hi, w_vbat2_lo_ibat_hi, w_ibat_lo_icpu_hi, w_icpu_lo_ipl = u16(rx, 17), u16(rx, 19), u16(rx, 21), \
              u16(rx, 23)
          peak, moda, lcs, lcn = rx[25], rx[26], rx[27], rx[28]
          out = _header(ctx, 'Power packet')
          out += 'sat_id          : %d (%s)\n' % (sat, source_desc(sat))
          out += _sclock_line('sclock          ', sclock)
          for lab, v, tail in (('spi             ', spi, '(total instant power)'), ('spa             ', spa, '(last 3 mins peak)'),
                               ('spb             ', spb, '(last 3 mins peak)'), ('spc             ', spc, '(last 3 mins peak)'),
                               ('spd             ', spd, '(last 3 mins peak)')):
              out += '%s: %4d mW %s\n' % (lab, v << 1, tail)
          out = out[:-1] + '\n\n'
          vbus1 = ((w_vbus_vbat_hi >> 4) * 1400) // 1000
          vbus2 = ((w_vcpu_lo_vbus2 & 0x0fff) * 4) & 0xFFFF
          vbus3 = ((w_vbus3_vbat2_hi >> 4) * 4) & 0xFFFF
          out += 'vbus1\t\t: %4d mV bus voltage read in CPU.ADC\n' % vbus1
          out += 'vbus2       \t: %4d mV bus voltage read in EPS.I2C\n' % vbus2
          out += 'vbus3       \t: %4d mV bus voltage read in CPU.I2C\n\n' % vbus3
          vbat1 = ((w_vbus_vbat_hi << 8) & 0x0f00) | ((w_vbat_lo_vcpu_hi >> 8) & 0x00ff)
          vbat1 = (vbat1 * 1400) // 1000
          out += 'vbat1\t\t: %4d mV bat voltage read in EPS.ADC\n' % vbat1
          vbat2 = (w_vbus3_vbat2_hi << 8) & 0x0f00
          vbat2 = (vbat2 | (w_vbat2_lo_ibat_hi >> 8)) & 0xFFFF
          vbat2 = (vbat2 * 4) & 0xFFFF
          out += 'vbat2\t\t: %4d mV bat voltage read in EPS.I2C\n\n' % vbat2
          ibat = (w_vbat2_lo_ibat_hi << 8) & 0xFFFF
          ibat = ibat | (w_ibat_lo_icpu_hi >> 8)
          if ibat & 0x0800:
              ibat = (ibat | 0xf000) & 0xFFFF
          ibats = s16(ibat)
          out += 'vbus1-vbat1\t: %4d mV \n' % s32(vbus1 - vbat1)
          out += 'vbus3-vbus2\t: %4d mV \n\n' % (vbus3 - vbus2)
          vcpu_temp = ((w_vbat_lo_vcpu_hi << 4) & 0x0ff0) | (w_vcpu_lo_vbus2 >> 12)
          vcpu = cdiv(1210 * 4096, vcpu_temp) & 0xFFFFFFFF
          icpu = (((w_ibat_lo_icpu_hi << 4) & 0x0ff0) | (w_icpu_lo_ipl >> 12)) & 0xFFFF
          icpus = s16(icpu)
          if icpus & 0x800:
              icpus = s16((icpus | 0xf000) * -1)
          ipls = s16(w_icpu_lo_ipl & 0x0fff)
          if ipls & 0x0800:
              ipls = s16(ipls | 0xf000)
          out += 'vcpu\t\t: %4d mV\n\n' % s32(vcpu)
          out += 'icpu\t\t: %4d mA @DCDCinput\n' % icpus
          iii = s32(icpus * vbus3)
          iii = s32(cdiv(iii & 0xFFFFFFFF, vcpu))                     # int / uint32: the int is converted to unsigned first
          out += 'icpu\t\t: %4d mA @DCDCoutput (estimation)\n' % iii
          out += 'ipl\t\t: %4d mA (Last payload current)\n' % ipls
          if ibats == 0:
              out += 'ibat\t\t: %4d mA\n\n' % ibats
          elif ibats > 0:
              out += 'ibat\t\t: %4d mA (Current flowing out from the battery)\n\n' % ibats
          else:
              out += 'ibat \t\t: %4d mA (Current flowing into the battery)\n\n' % ibats
          out += 'peaksignal\t: %4d dB\n' % peak
          out += 'modasignal\t: %4d dB\n' % moda
          out += 'lastcmdsignal\t: %4d dB\n' % lcs
          out += 'lastcmdnoise\t: %4d dB\n' % lcn
          dat = '%d %d %d %d %d %d %d %d ' % (ctx.t, 0, s32(sclock), spa << 1, spb << 1, spc << 1, spd << 1, spi << 1)
          dat += '%d %d %d %d %d %d %d %d %d ' % (s32(vbus1), s32(vbat1), s32(vcpu), vbus2, vbus3, vbat2, ibats, icpus, ipls)
          dat += '%d %d %d %d\n' % (peak, moda, lcs, lcn)
          return out, dat.encode('latin-1')


      def _temp_line(label, v, text):
          if v == 255:
              return '%s: \n' % label
          return '%s: %+5.1f %s\n' % (label, v / 2 - 40.0, text)


      def decode_temp(rx, sat, ctx):
          sclock = u32(rx, 1)
          tpa, tpb, tpc, tpd, tpe, teps, ttx, ttx2, trx, tcpu = rx[5:15]
          out = _header(ctx, 'Temp packet')
          out += 'sat_id : %d (%s)\n' % (sat, source_desc(sat))
          out += _sclock_line('sclock ', sclock)
          for lab, v, tx in (('tpa    ', tpa, 'degC temperature in SPA.I2C'), ('tpb    ', tpb, 'degC temperature in SPB.I2C'),
                             ('tpc    ', tpc, 'degC temperature in SPC.I2C'), ('tpd    ', tpd, 'degC temperature in SPD.I2C'),
                             ('teps   ', teps, 'degC temperature in EPS.I2C'), ('ttx    ', ttx, 'degC temperature in  TX.I2C'),
                             ('ttx2   ', ttx2, 'degC temperature in  TX.NTC'), ('trx    ', trx, 'degC temperature in  RX.NTC'),
                             ('tcpu   ', tcpu, 'degC temperature in CPU.ADC')):
              out += _temp_line(lab, v, tx)
          dat = '%d %d' % (ctx.t, 0) + ''.join(' %+5.1f' % (v / 2 - 40.0) for v in (tpa, tpb, tpc, tpd, tpe, teps, ttx, ttx2,
                                                                                trx, tcpu)) + '\n'
          return out, dat.encode('latin-1')


      def decode_status(rx, sat, ctx):
          sclock, uptime, nrun = u32(rx, 1), u32(rx, 5), u16(rx, 9)
          npayload, nwire, ntransponder, nplr, bate_mote, subsys, ntasks, antenna, neeprom, failed_task, niot, sf0 = \
              rx[11], rx[12], rx[13], rx[14], rx[15], rx[16], rx[17], rx[18], rx[19], rx[20], rx[21], rx[22]
          sf1, sf2, sf3 = u16(rx, 23), u16(rx, 25), rx[27]
          pct = rx[28:36]
          pframes, pparams, pimg = rx[36], rx[37], rx[38]
          hades_l = (sat == 5)
          d, h, m, s = _dhms(sclock)
          du, hu, mu, su = _dhms(uptime)
          out = _header(ctx, 'Status packet')
          out += 'sat_id              : %10d (%s)\n' % (sat, source_desc(sat))
          out += 'sclock              : %10d seconds satellite has been active (%d days and %02d:%02d:%02d hh:mm:ss)\n' % (
              s32(sclock), d, h, m, s)
          out += 'uptime              : %10d seconds since the last CPU reset  (%d days and %02d:%02d:%02d hh:mm:ss)\n' % (
              s32(uptime), du, hu, mu, su)
          out += 'nrun                : %10d times satellite CPU was started\n' % nrun
          out += 'npayload            : %10d times payload was activated\n' % npayload
          out += 'nwire               : %10d times antenna deployment was tried\n' % nwire
          out += 'ntransponder        : %10d times transponder was activated\n' % ntransponder
          if (nplr >> 4) == 0:
              out += 'nPayloadsFails \t    :  \t       OK\n'
          else:
              out += 'nPayloadFails       : %10d\n' % (nplr >> 4)
          out += 'last_reset_cause    : %10d %s\n' % (nplr & 0x0F, reset_cause_name(nplr & 0x0F))
          out += 'bate (battery)      : %10X %s\n' % (bate_mote >> 4, battery_status(bate_mote >> 4))
          e0, e1 = subsys & 1, (subsys >> 1) & 1
          if e0 == 1 and e1 == 1:
              out += 'power amplifier     :          OK\n'
          elif e0 == 1 and e1 == 0:
              out += 'power amplifier     :          FAIL\n'
          elif e0 == 0:
              out += 'power amplifier     :          Disabled\n'
          out += 'high speed uplink   :          %s\n' % ('OK' if (subsys >> 2) & 1 else 'Disabled')
          out += 'tx temp compensat   :          %s\n' % ('OK' if (subsys >> 3) & 1 else 'Disabled')
          if hades_l:                                      # HADES-L: the receiver board has an enable flag and a status flag
              if (subsys >> 4) & 1:
                  out += 'RX board enabled    :          OK\n'
              else:
                  out += 'RX board            :          Disabled\n'
              out += 'RX board status     :          %s\n' % ('OK' if (subsys >> 6) & 1 else 'Unavailable')
          else:
              out += 'RX board            :          %s\n' % ('OK' if (subsys >> 4) & 1 else 'Disabled')
          out += 'Variable messaging  :          %s\n' % ('OK' if (subsys >> 5) & 1 else 'Disabled')
          out += 'mote (transponder)  : %s\n' % transponder_mode(bate_mote & 0x0f, hades_l)
          if ntasks == 0:
              out += 'nTasksNotExecuted   :          OK\n'
          else:
              out += 'nTasksNotExecuted   : %10d Some tasks missed their execution time\n' % ntasks
          if neeprom == 0:
              out += 'nExtEepromErrors    :          OK\n'
          else:
              out += 'nExtEepromErrors    : %10d EEPROM Fail\n' % neeprom
          not_dep, dep = (1, 0) if sat in (2, 13, 3) else (0, 1)
          if antenna == not_dep:
              out += 'antennaDeployed     :          KO (Antenna not yet deployed)\n'
          elif antenna == 2:
              out += 'antennaDeployed     :          UNKNOWN\n'
          elif antenna == dep:
              out += 'antennaDeployed     :          OK (Antenna has been deployed)\n'
          if ntasks == 0:
              out += 'last_failed_task_id :          OK\n'
          else:
              out += 'last_failed_task_id :          Q%dT%d\n' % (failed_task >> 6, failed_task & 0b00111111)
          out += 'strfwd0 (id)        : %10X (%d)\n' % (sf0, sf0)
          out += 'strfwd1 (key)       : %10X (%d)\n' % (sf1, sf1)
          out += 'strfwd2 (value)     : %10X (%d)\n' % (sf2, sf2)
          out += 'strfwd3 (num_tcmds) : %10X (%d)\n' % (sf3, sf3)
          for lab, v in zip(('rx_percent          ', 'telemetry_percent   ', 'transponder_percent ', 'ptt_hp_percent      ',
                             'ptt_lp_percent      ', 'ple_percent         ', 'bwe_percent         ',
                             'vbat_higher_vbus_p  '), pct):
              out += '%s: %10d%%\n' % (lab, v)
          if hades_l:                                      # HADES-L: the Lofith store replaces the payload counters
              out += 'stored_frames       : %10d\n' % pframes
              out += 'frames_last batch   : %10d\n' % pimg
          else:
              out += 'payload frames      : %10d\n' % pframes
              out += 'payload params      : %10d\n' % pparams
              out += 'payload current img : %10d\n' % pimg
          vals = [s32(sclock), s32(uptime), nrun, npayload, nwire, ntransponder, nplr >> 4, nplr & 0x0F, bate_mote >> 4,
                  bate_mote & 0x0f, ntasks, antenna, neeprom, failed_task >> 6, niot, sf0, sf1, sf2, sf3] + list(pct) + \
              ([pframes, pimg] if hades_l else [pframes])
          dat = '%d %d ' % (ctx.t, 0) + ' '.join('%d' % v for v in vals) + '\n'
          return out, dat.encode('latin-1')


      def _vcpu_range(w_hi, b_lo):
          t = (((w_hi << 4) & 0x0ff0) | (b_lo >> 4))
          return cdiv(1210 * 4096, t)


      def decode_power_ranges(rx, sat, ctx):
          sclock = u32(rx, 1)
          minvv, minvb, minvc_lo = u16(rx, 5), u16(rx, 7), rx[9]
          minvbus2, minvbus3, minvbat2, minibat, minicpu, minipl = rx[10:16]
          maxvv, maxvb, maxvc_lo = u16(rx, 16), u16(rx, 18), rx[20]
          maxvbus2, maxvbus3, maxvbat2, maxibat, maxicpu, maxipl = rx[21:27]
          ib = rx[27:33]
          minicpus = minicpu - 256 if minicpu > 127 else minicpu
          maxicpus = maxicpu - 256 if maxicpu > 127 else maxicpu
          d, h, m, s = _dhms(sclock)

          def vbus1(w):
              return 1400 * (w >> 4) // 1000

          def vbat1(wv, wb):
              return 1400 * (((wv << 8) & 0x0f00) | ((wb >> 8) & 0x00ff)) // 1000
          minvcpu = _vcpu_range(minvb, minvc_lo)
          maxvcpu = _vcpu_range(maxvb, maxvc_lo)
          out = _header(ctx, 'Power ranges packet')
          out += 'sat_id         : %d (%s)\n' % (sat, source_desc(sat))
          out += 'sclock         : %d seconds (%d days and %02d:%02d:%02d hh:mm:ss)\n' % (s32(sclock), d, h, m, s)
          out += 'minvbus1       : %4d mV ADC\n' % vbus1(minvv)
          out += 'minvbat1       : %4d mV ADC\n' % vbat1(minvv, minvb)
          out += 'minvcpu        : %4d mV ADC\n' % minvcpu
          out += 'minvbus2       : %4d mV I2C\n' % (minvbus2 * 16 * 4)
          out += 'minvbus3       : %4d mV I2C\n' % (minvbus3 * 16 * 4)
          out += 'minvbat2       : %4d mV I2C\n' % (minvbat2 * 16 * 4)
          out += 'minibat        : %4d mA I2C (Max current flowing into the battery)\n' % (-1 * minibat)
          out += 'minicpu        : %4d mA I2C\n' % minicpus
          out += 'minipl         : %4d mA I2C (Payload current)\n' % minipl
          out += 'maxvbus1       : %4d mV ADC\n' % vbus1(maxvv)
          out += 'maxvbat1       : %4d mV ADC\n' % vbat1(maxvv, maxvb)
          out += 'maxvcpu        : %4d mV ADC\n' % maxvcpu
          out += 'maxvbus2       : %4d mV I2C\n' % (maxvbus2 * 16 * 4)
          out += 'maxvbus3       : %4d mV I2C\n' % (maxvbus3 * 16 * 4)
          out += 'maxvbat2       : %4d mV I2C\n' % (maxvbat2 * 16 * 4)
          out += 'maxibat        : %4d mA I2C (Max current flowing out from the battery)\n' % maxibat
          out += 'maxicpu        : %4d mA I2C\n' % maxicpus
          out += 'maxipl         : %4d mA I2C (Payload current)\n' % (maxipl << 2)
          out += '\n'
          for lab, v in zip(('ibat_tx_off_charging           ', 'ibat_tx_off_discharging        ',
                             'ibat_tx_low_power_charging     ', 'ibat_tx_low_power_discharging  ',
                             'ibat_tx_high_power_charging    ', 'ibat_tx_high_power_discharging '), ib):
              out += '%s: %4d mA I2C\n' % (lab, v)
          vals = [s32(sclock), vbus1(minvv), vbat1(minvv, minvb), minvcpu, minvbus2 * 64, minvbus3 * 64, minvbat2 * 64,
                  -1 * minibat, minicpus, minipl, vbus1(maxvv), vbat1(maxvv, maxvb), maxvcpu, maxvbus2 * 64, maxvbus3 * 64,
                  maxvbat2 * 64, maxibat, maxicpus, maxipl << 2] + list(ib)
          dat = '%d %d ' % (ctx.t, 0) + ' '.join('%d' % v for v in vals) + '\n'
          return out, dat.encode('latin-1')


      def decode_temp_ranges(rx, sat, ctx):
          sclock = u32(rx, 1)
          mins, maxs = rx[5:15], rx[15:25]
          d, h, m, s = _dhms(sclock)
          out = _header(ctx, 'Temperature ranges packet')
          out += 'sat_id         : %d (%s)\n' % (sat, source_desc(sat))
          out += 'sclock         : %d seconds (%d days and %02d:%02d:%02d hh:mm:ss)\n' % (s32(sclock), d, h, m, s)
          names = ['tpa', 'tpb', 'tpc', 'tpd', 'tpe', 'teps', 'ttx', 'ttx2', 'trx', 'tcpu']
          texts = ['C MCP Temperature outside panel A', 'C MCP Temperature outside panel B',
                   'C MCP Temperature outside panel C', 'C MCP Temperature outside panel D', None,
                   'C TMP100 Temperature EPS', 'C TMP100 Temperature TX', 'C ADC Temperature TX', 'C ADC Temperature RX',
                   'C INT Temperature CPU']
          for prefix, arr, pad in (('min', mins, ''), ('max', maxs, '')):
              for n, v, tx in zip(names, arr, texts):
                  label = (prefix + n).ljust(15)
                  if v == 255 or tx is None:
                      out += '%s: \n' % label
                  else:
                      out += '%s: %+5.1f %s\n' % (label, v / 2 - 40.0, tx)
          vals = ['%f' % ((v // 2) - 40.0) for v in mins[:4]] + ['%f' % 0.0] + ['%f' % ((v // 2) - 40.0) for v in mins[5:]] + \
              ['%f' % ((v // 2) - 40.0) for v in maxs[:4]] + ['%f' % 0.0] + ['%f' % ((v // 2) - 40.0) for v in maxs[5:]]
          dat = '%d %d %d ' % (ctx.t, 0, s32(sclock)) + ' '.join(vals) + '\n'
          return out, dat.encode('latin-1')


      def decode_deploy(rx, sat, ctx):
          v1oc, v1, i1, i1pk, r1, v2oc, v2, r2 = (u16(rx, 1 + 2 * k) for k in range(8))
          t0, td = u32(rx, 17), u16(rx, 21)
          sb, se, sn, enable, counter, tmp = rx[23:29]
          out = _header(ctx, 'Antenna deployment packet')
          out += 'sat_id                                     : %d (%s)\n' % (sat, source_desc(sat))
          out += 'estado pulsador inicio:fin:ahora           : %d:%d:%d\n' % (sb, se, sn)
          out += 'tension bateria en circuito abierto Voc/mV : %d\n' % v1oc
          out += 'caida de tension deltaV/mV                 : %u\n' % v1
          out += 'corriente quemado Ibr/mA                   : %u\n' % i1
          out += 'corriente quemado Ibr,pk/mA                : %u\n' % i1pk
          out += 'resistencia interna bateria Rbat/mohm      : %u\n' % r1
          out += 'tiempo quemado observado t/s               : %d\n' % td
          dat = '%d %d ' % (ctx.t, 0) + '%d %u %u %u %u %u %d %d %d %d %d %d %d %d %d %d\n' % (
              v1oc, v1, i1, i1pk, r1, v2oc, v2, r2, s32(t0), td, sb, se, sn, enable, counter, tmp)
          return out, dat.encode('latin-1')


      def decode_ine(rx, sat, ctx):
          out = _header(ctx, 'Extended power (ine) packet')
          out += 'sat_id : %d (%s)\n\n' % (sat, source_desc(sat))
          dat = '%d %d ' % (ctx.t, 0)
          for n in range(10):
              v, i, p, vp, ip, pp = (s16(u16(rx, 1 + 12 * n + 2 * k)) for k in range(6))
              out += '%2d %4s | VI %5d [mV] %5d [mA] | AOP %5d [mW] | VIPpeak %5d [mV] %5d [mA] %5d [mW]\n' % (
                  n, INE_NAMES[n], v, i, p, vp, ip, pp)
              dat += '%2d %4s %5d %5d %5d %5d %5d %5d ' % (n, INE_NAMES[n], v, i, p, vp, ip, pp)
          dat += '\n'
          return out, dat.encode('latin-1')


      def codec2_frame_bytes(rx):
          """40 bytes ready for c2dec: the 35 payload bytes XOR-whitened, then 10 x (28 bits + 4 zero bits)."""
          bits = bytes(a ^ b for a, b in zip(rx[2:37], VOICE_XOR_KEY))
          value = int.from_bytes(bits, 'big')
          out = bytearray()
          for f in range(10):
              frame = (value >> (280 - 28 * (f + 1))) & 0x0FFFFFFF
              out += (frame << 4).to_bytes(4, 'big')
          return bytes(out)


      def decode_codec2(rx, sat, ctx):
          data = codec2_frame_bytes(rx)
          out = _header(ctx, 'Codec2 frame')
          out += 'sat_id    : %d (%s)\n' % (sat, source_desc(sat))
          out += 'frame num : %d\n' % rx[1]
          out += 'data      : ' + ''.join('%02X ' % b for b in data) + '\n'
          return out, data


      def ssdv_file(rx):
          """The 256-byte SSDV packet the original writes: 55 66 BF35 FB then the 251 received bytes."""
          return b'\x55\x66\xbf\x35\xfb' + bytes(rx[:251])


      def decode_ssdv(rx, sat, ctx):
          if sat == 5:                                     # HADES-L has no camera: its decoder keeps the packet but writes no text
              return '', ssdv_file(rx)
          image_id = rx[1]
          packet_id = (rx[2] << 8) | rx[3]
          width, height, flags, mcu_off = rx[4], rx[5], rx[6], rx[7]
          mcu_index = (rx[8] << 8) | rx[9]
          out = _header(ctx, 'SSDV frame')
          out += 'sat_id    : %d (%s)\n' % (sat, source_desc(sat))
          out += 'image id  : %d\n' % image_id
          out += 'packet id : %d\n' % packet_id
          out += 'width id  : %03d\n' % (16 * width)
          out += 'height id : %03d\n' % (16 * height)
          out += 'flags     : %03d\n' % flags
          out += 'mcuOffset : %03d\n' % mcu_off
          out += 'mcuIndex  : %d\n' % mcu_index
          out += 'checksum  : ' + ''.join('%02X' % b for b in rx[215:219]) + '\n'
          out += 'FEC       : ' + ''.join('%02X' % b for b in rx[219:251]) + '\n'
          return out, ssdv_file(rx)


      def decode_pn9(rx, sat, ctx):
          pn9 = rx[1:249]
          match = sum(1 for a, b in zip(pn9, PN9_RAW_DATA) if a == b)
          wrong = len(PN9_RAW_DATA) - match
          out = _header(ctx, 'PN9 frame')
          out += 'sat_id    : %d (%s)\n' % (sat, source_desc(sat))
          out += 'data      : ' + ''.join('%02X ' % b for b in pn9) + '\n\n'
          if match + wrong > 0:
              out += '%s Data matching rate : %6.2f%% (Total %d, failed %d)\n' % (
                  ctx.fecha, match * 100.0 / (match + wrong), match + wrong, wrong)
          else:
              out += '%s Data matching rate : N/A\n' % ctx.fecha
          return out, ''.join('%02X ' % b for b in pn9).encode('latin-1')


      def decode_bbs(rx, sat, ctx):
          callsigns, messages, frames = rx[1:31], rx[31:66], rx[66:71]
          out = _header(ctx, 'BBS packet')
          out += 'sat_id        : %d (%s)\n\n' % (sat, source_desc(sat))
          out += 'BBS contents  : Callsign Message Codec2 frames\n'
          for i in range(5):
              out += '                ' + ''.join(chr(b) for b in callsigns[i * 6:i * 6 + 6]) + '   ' + \
                     ''.join(chr(b) for b in messages[i * 7:i * 7 + 7]) + ' ' + '%d\n' % frames[i]
          return out, b''


      def _f32(rx, i, big):
          return struct.unpack('>f' if big else '<f', bytes(rx[i:i + 4]))[0]


      def decode_ephemeris(rx, sat, ctx, tle_big_endian=False):
          """Ephemeris: the frame structure is big-endian; the nested TLE structure uses the compiler's native (little)
          order in the original, which `tle_big_endian=False` reproduces."""
          utc = be32(rx, 1)
          adr, ful, fdl = be16(rx, 5), be32(rx, 7), be32(rx, 11)
          epoch = struct.unpack('>I' if tle_big_endian else '<I', bytes(rx[15:19]))[0]
          floats = [_f32(rx, 19 + 4 * k, tle_big_endian) for k in range(9)]
          lat, lon = struct.unpack('>hh', bytes(rx[55:59]))
          alt = be16(rx, 59)

          def stamp(sec):
              sec = s32(sec)                      # the Windows tool's time_t is a signed 32-bit number
              d = datetime.datetime.fromtimestamp(sec, datetime.timezone.utc)
              return '%04d-%02d-%02d %02d:%02d:%02d' % (d.year, d.month, d.day, d.hour, d.minute, d.second)
          out = _header(ctx, 'Ephemeris packet')
          out += 'sat_id      : %d (%s)\n' % (sat, source_desc(sat))
          out += 'UTC time    : %d seconds (%s) (on board) YYYY-MM-DD HH24:MI:SS\n' % (s32(utc), stamp(utc))
          out += 'lat         : %d degrees\n' % lat
          out += 'lon         : %d degrees\n' % lon
          out += 'alt         : %d km\n' % alt
          if utc == 0 or epoch == 0:
              out += 'zone        : unknown\n'
          else:
              out += 'zone        : %s\n' % overflying(lat, lon)
          out += 'Adr         : %d\n' % adr
          out += 'Ful         : %d\n' % s32(ful)
          out += 'Fdl         : %d\n' % s32(fdl)
          out += 'Epoch       : %d seconds (%s) (TLE time) YYYY-MM-DD HH24:MI:SS\n' % (s32(epoch), stamp(epoch))
          for lab, v in zip(('Xndt2o ', 'Xndd6o ', 'Bstar  ', 'Xincl  ', 'Xnodeo ', 'Eo     ', 'Omegao ', 'Xmo    ', 'Xno    '),
                            floats):
              out += '%s     : %s\n' % (lab, cf(v))
          dat = '%d %d ' % (ctx.t, 0) + '%d %d %d %d %d ' % (s32(utc), adr, s32(ful), s32(fdl), s32(epoch)) + \
              ' '.join(cf(v) for v in floats) + ' %d %d %d 0\n' % (lat, lon, alt)
          return out, dat.encode('latin-1')


      def decode_time_series(rx, sat, ctx):
          clock = u32(rx, 1)
          variable = rx[5]
          data = rx[6:36]
          d, h, m, s = _dhms(clock)
          out = _header(ctx, 'Time series packet')
          out += 'sat_id      : %d (%s)\n' % (sat, source_desc(sat))
          out += 'sclock\t    : %d seconds (%d days and %02d:%02d:%02d hh:mm:ss)\n' % (s32(clock), d, h, m, s)
          desc = TIME_SERIES_DESC_L if sat == 5 else TIME_SERIES_DESC
          out += 'Variable    : %d (%s)\n' % (variable, desc[variable] if variable < 6 else 'Unknown')
          dat = '%d %d ' % (ctx.t, 0)
          for i, v in enumerate(data):
              age = (29 - i) * 3
              if variable in (0, 1):
                  out += 'Data [%03d]  :  %.2X (%03d dB) Sampled (T-%03d) minutes\n' % (i, v, v, age)
                  dat += '%d ' % v
              elif variable == 2:
                  vb = ((v << 4) * 1400) // 1000
                  out += 'Data [%03d]  : %4d mV bat voltage read in EPS.ADC - Sampled at (T-%03d) minutes\n' % (i, vb, age)
                  dat += '%d ' % vb
              elif variable in (3, 4, 5):
                  text = {3: 'degC temperature in CPU.ADC', 4: 'degC temperature in SPA.I2C',
                          5: 'degC temperature mean 4 panels (SPA-SPD).I2C'}[variable]
                  blank = {3: 'degC temperature in CPU.ADC', 4: 'degC temperature in SPB.I2C',
                           5: 'degC temperature mean 4 panels (SPA-SPD).I2C'}[variable]
                  if sat == 5 and variable == 4:                       # HADES-L: panel C in both lines
                      text = blank = 'degC temperature in SPC.I2C'
                  if v == 255:
                      out += 'Data [%03d]  :       %s - Sampled at (T-%03d) minutes\n' % (i, blank, age)
                  else:
                      out += 'Data [%03d]  : %+5.1f %s - Sampled at (T-%03d) minutes\n' % (i, v / 2 - 40.0, text, age)
                  dat += '%5.1f ' % (v / 2.0 - 40.0)
              else:
                  out += 'Data [%03d]\t:  %.2X (%03d) Sampled (T-%03d) minutes\n' % (i, v, v, age)
                  dat += '%d ' % v
          dat += '\n'
          return out, dat.encode('latin-1')


      def decode_lofith(rx, sat, ctx):
          """HADES-L type 7: one frame of the Lofith experiment (23 bytes: type/address, 20 data bytes, CRC)."""
          total, ts, number = rx[1], u32(rx, 2), rx[6]
          gauge, gref, vref, pref = s16(u16(rx, 7)), s16(u16(rx, 9)), s16(u16(rx, 11)), s16(u16(rx, 13))
          temp, rad1, rad2 = s16(u16(rx, 15)), u16(rx, 17), u16(rx, 19)
          d, h, m, sec = _dhms(ts)
          out = _header(ctx, 'Lofith payload packet')
          out += 'sat_id           : %d (%s)\n' % (sat, source_desc(sat))
          out += 'total frames     : %d\n' % total
          out += 'timestamp        : %d seconds (satellite clock was %d days and %02d:%02d:%02d hh:mm:ss)\n' % (s32(ts), d, h, m, sec)
          out += 'frame number     : %d\n' % number
          out += 'gaugue value     : %d\n' % gauge
          out += 'gauge ref value  : %d\n' % gref
          out += 'vbus ref voltage : %d\n' % vref
          out += 'payload ref      : %d\n' % pref
          if temp == 255:
              out += 'satellite temp   :\n'
          else:
              out += 'satellite temp   : %+5.1f degC\n' % (temp / 2.0 - 40.0)
          out += 'radiation cont 1 : %d\n' % rad1
          out += 'radiation cont 2 : %d\n\n' % rad2
          dat = '%d %d %d %d %d %d %d %d %d %f %d %d\n' % (ctx.t, 0, total, s32(ts), number, gauge, gref, vref, pref,
                                                            temp / 2.0 - 40.0, rad1, rad2)
          return out, dat.encode('latin-1')


      def decode_icm(rx, sat, ctx):
          """HADES-L type 15: an ICM story message (101 bytes: type/address, tx time, message number, 93 characters, CRC)."""
          ts, number = u32(rx, 1), rx[5]
          d, h, m, sec = _dhms(ts)
          out = '*** ICM message received on %s %s ***\n' % (ctx.zone, ctx.fecha)
          out += 'sat_id         : %d (%s)\n' % (sat, source_desc(sat))
          out += 'tx time        : %d seconds (satellite clock was %d days and %02d:%02d:%02d hh:mm:ss)\n' % (s32(ts), d, h, m, sec)
          out += 'Message number : %03d\n' % number
          out += 'Message        : ' + ''.join(chr(b) for b in rx[6:99]) + '\n'
          return out, b''


      DECODERS = {1: decode_power, 2: decode_temp, 3: decode_status, 4: decode_power_ranges, 5: decode_temp_ranges,
                  8: decode_deploy, 9: decode_ine, 10: decode_ssdv, 11: decode_codec2, 12: decode_ephemeris,
                  13: decode_pn9, 14: decode_time_series, 15: decode_bbs}
      DECODERS_L = {**DECODERS, 7: decode_lofith, 15: decode_icm}               # HADES-L: Lofith data and ICM messages
      DECODERS_BY_SOURCE = {3: DECODERS, 5: DECODERS_L}


      def decoders_for(source):
          return DECODERS_BY_SOURCE.get(source, DECODERS)

      # ---- file names and writing --------------------------------------------------------------------------------------


      def frame_for_decoder(ptype, source, plain):
          """Build the byte string the decoders take (`rx`) from a deframer frame (type/address + descrambled data, no CRC),
          padding the CRC bytes the original expects so offsets and lengths match."""
          rx = bytes(plain)
          want = frame_size(source, ptype) or len(rx)
          if len(rx) < want:
              rx = rx + bytes(want - len(rx))
          return rx


      def names_for(ptype, source, rx, ctx, as_type=None):
          """(timestamped .tlm, latest .tlm, data file, data mode) exactly as the original names them."""
          if ptype == 10:
              key = 'sat_%02d_type_%02d_ssdv_img_%03d_packet_%04d' % (source, ptype, rx[1], (rx[2] << 8) | rx[3])
              return ('%s_%s.tlm' % (ctx.fecha_fichero, key), key + '.tlm', key + '.bin', 'wb')
          if ptype == 11:
              key = 'sat_%02d_type_%02d_codec2_frame_%03d' % (source, as_type if as_type is not None else ptype, rx[1])
              return ('%s_%s.tlm' % (ctx.fecha_fichero, key), key + '.tlm', key + '.bin', 'wb')
          if ptype == 7 and source == 5:                       # HADES-L Lofith: one file set per frame number
              key = 'sat_%02d_type_%02d_lofith_frame_%03d' % (source, ptype, rx[6])
              return ('%s_%s.tlm' % (ctx.fecha_fichero, key), key + '.tlm', key + '.dat', 'ab')
          if ptype == 14:
              key = 'sat_%02d_type_%02d_%02d' % (source, ptype, rx[5])
              return ('%s_%s.tlm' % (ctx.fecha_fichero, key), key + '.tlm', key + '.dat', 'ab')
          key = 'sat_%02d_type_%02d' % (source, ptype)
          return ('%s_%s.tlm' % (ctx.fecha_fichero, key), key + '.tlm', key + '.dat', 'ab')


      def decode_frame(ptype, source, plain, ctx, voice=False):
          """-> (tlm text, dat bytes, names tuple) or None when there is no decoder for the type."""
          if voice:                                                  # CODEC2 voice: type 11 (HADES) or 15 (UNNE-1B)
              rx = bytes(plain)
              text, dat = decode_codec2(rx, source, ctx)
              return text, dat, names_for(11, source, rx, ctx, as_type=ptype)
          fn = decoders_for(source).get(ptype)
          if fn is None:
              return None
          rx = frame_for_decoder(ptype, source, plain)
          text, dat = fn(rx, source, ctx)
          return text, dat, names_for(ptype, source, rx, ctx)


      # satellites whose frames the decoders above understand: HADES-SA (3) and HADES-L (5), each checked against its own
      # package's decoder DLL (hadessa.dll / hadesl.dll)
      NATIVE_SOURCES = (3, 5)


      PICTURE_LOG = 'ssdv_log.csv'                         # one line per new picture packet, see FolderWriter


      class FolderWriter(object):
          """Writes frames into a folder the way AMSAT-EA's tool does, and only adds what is new:

          * `.tlm` latest text is replaced, a copy per reception is kept (turn off with history=False);
          * `.dat` lines are appended, but a line identical to an existing one (apart from the time columns) is skipped, so
            processing the same recording twice, or overlapping recordings, adds nothing;
          * `.bin` voice / image files are replaced by the newest copy of that frame / packet number.
          """

          def __init__(self, outdir, utc=True, history=True, fallback=None, source=None):
              """fallback(frame) -> text: used for frames of satellites without a native decoder (UNNE-1B); default is a
              short raw-bytes description.  source: name of the recording being added (written to the picture packet log)."""
              self.source = source
              self.outdir = outdir
              self.utc = utc
              self.history = history
              self.fallback = fallback
              os.makedirs(outdir, exist_ok=True)
              self.stats = {'frames': 0, 'new_dat_lines': 0, 'skipped_duplicates': 0, 'files': set(), 'by_type': {}, 'new_by_type': {}}

          def _path(self, name):
              return os.path.join(self.outdir, name)

          def _append_unique(self, name, line):
              path = self._path(name)
              tail = line.split(b' ', 2)[2:] if line.count(b' ') >= 2 else [line]
              key = tail[0] if tail else line
              if os.path.exists(path):
                  with open(path, 'rb') as f:
                      for old in f:
                          parts = old.split(b' ', 2)
                          if len(parts) >= 3 and parts[2] == key:
                              return False
              with open(path, 'ab') as f:
                  f.write(line)
              return True

          def _write_generic(self, frame, t):
              """Frames without a native decoder (UNNE-1B telemetry): same file names, text from the fallback and one raw
              hex line per frame in the .dat file."""
              ptype, source = frame['type'], frame['src']
              ctx = Ctx(t, self.utc)
              key = 'sat_%02d_type_%02d' % (source, ptype)
              text = self.fallback(frame) if self.fallback else \
                  '*** %s packet type %d received on %s %s ***\ndata (descrambled): %s\n' % (
                      frame.get('src_name', 'satellite'), ptype, ctx.zone, ctx.fecha, frame['plain'])
              data = (text if text.endswith('\n') else text + '\n').encode('latin-1', 'replace')
              touched = []
              if self.history:
                  n = '%s_%s.tlm' % (ctx.fecha_fichero, key)
                  with open(self._path(n), 'wb') as f:
                      f.write(data)
                  touched.append(n)
              with open(self._path(key + '.tlm'), 'wb') as f:
                  f.write(data)
              touched.append(key + '.tlm')
              line = ('%d 0 %s\n' % (ctx.t, frame['plain'])).encode('latin-1')
              if self._append_unique(key + '.dat', line):
                  self.stats['new_dat_lines'] += 1
              else:
                  self.stats['skipped_duplicates'] += 1
              touched.append(key + '.dat')
              return touched

          def write(self, frame, t):
              """frame: a deframer frame dict (type, src, plain, voice ...).  t: reception time (epoch seconds).
              Returns the list of files touched."""
              ptype, source = frame['type'], frame['src']
              if frame.get('crc_ok') is False:                          # shown with --emit-unverified: never stored
                  self.stats['unverified_skipped'] = self.stats.get('unverified_skipped', 0) + 1
                  return []
              plain = bytes.fromhex(frame['plain'])
              voice = bool(frame.get('voice'))
              if voice:                                                 # voice payload only: rebuild type/number/payload
                  plain = bytes([(ptype << 4) | source, frame['number']]) + plain
              if not voice and (source not in NATIVE_SOURCES or ptype not in decoders_for(source)):
                  touched = self._write_generic(frame, t)
                  self._count(source, ptype, touched)
                  return touched
              res = decode_frame(ptype, source, plain, Ctx(t, self.utc), voice=voice)
              text, dat, (n_hist, n_tlm, n_dat, mode) = res
              touched = []
              data = text.encode('latin-1')
              if self.history:
                  with open(self._path(n_hist), 'wb') as f:
                      f.write(data)
                  touched.append(n_hist)
              with open(self._path(n_tlm), 'wb') as f:
                  f.write(data)
              touched.append(n_tlm)
              if mode == 'wb':
                  new_packet = ptype == 10 and not voice and not os.path.exists(self._path(n_dat))
                  if new_packet or (voice and self._differs(n_dat, dat)):      # new to the folder (voice: or changed)
                      k = (source, ptype)
                      self.stats['new_by_type'][k] = self.stats['new_by_type'].get(k, 0) + 1
                  with open(self._path(n_dat), 'wb') as f:
                      f.write(dat)
                  self.stats['new_dat_lines'] += 1
                  if new_packet:
                      self._log_picture_packet(n_dat, t)
              elif ptype == 13 or not dat:                              # PN9 hex stream / BBS (empty .dat): as the original
                  with open(self._path(n_dat), 'ab') as f:
                      f.write(dat)
                  self.stats['new_dat_lines'] += 1 if dat else 0
              elif self._append_unique(n_dat, dat):
                  self.stats['new_dat_lines'] += 1
              else:
                  self.stats['skipped_duplicates'] += 1
              touched.append(n_dat)
              self._count(source, ptype, touched)
              return touched

          def _differs(self, name, data):
              """True when the file is missing or holds something else than data."""
              try:
                  with open(self._path(name), 'rb') as f:
                      return f.read() != data
              except OSError:
                  return True

          def _log_picture_packet(self, name, t):
              """A picture (SSDV) packet that was not in the folder before: one line in ssdv_log.csv (when it was added,
              when it was received, which image and packet, from which recording)."""
              m = re.search(r'_ssdv_img_(\d+)_packet_(\d+)\.bin$', name)
              if not m:
                  return
              import csv
              path = self._path(PICTURE_LOG)
              fresh = not os.path.exists(path)
              with open(path, 'a', newline='') as f:
                  w = csv.writer(f)
                  if fresh:
                      w.writerow(['added_utc', 'received_utc', 'image', 'packet', 'recording'])
                  now = time.time()
                  w.writerow([time.strftime('%Y-%m-%dT%H:%M:%S', time.gmtime(now)) + '.%03dZ' % int((now % 1) * 1000),
                              time.strftime('%Y-%m-%dT%H:%M:%SZ', time.gmtime(t)), int(m.group(1)), int(m.group(2)), self.source or ''])
              self.stats['new_picture_packets'] = self.stats.get('new_picture_packets', 0) + 1

          def _count(self, source, ptype, touched):
              self.stats['frames'] += 1
              self.stats['files'].update(touched)
              k = (source, ptype)
              self.stats['by_type'][k] = self.stats['by_type'].get(k, 0) + 1


      # ----------------------------------------------------------------------------
      # GNU Radio Embedded Python block: deframer
      # ----------------------------------------------------------------------------
      import pmt
      from gnuradio import gr


      class blk(gr.sync_block):
          """UNNE-1B / HADES-SA / HADES-L FSK deframer: complex baseband in, demodulated FSK out, decoded frames printed"""

          def __init__(self, samp_rate=10000.0, bauds='200,800', max_flips=3, dll_path='', log_path='', c2_path='',
                       hex_time='none', rec_start='', delay_s=1.2, emit_unverified=False, out_dir='', out_history=True):
              gr.sync_block.__init__(self, name='UNNE-1B / HADES FSK deframer',
                                     in_sig=[np.complex64], out_sig=[np.float32])
              self.message_port_register_out(pmt.intern('frames'))
              self.message_port_register_out(pmt.intern('hex'))
              # one deframer per baud rate: UNNE-1B = 200, HADES-SA alternates 800 / 200, HADES-L = 800
              self.df = MultiBaudDeframer(fs=float(samp_rate), bauds=parse_bauds(bauds), max_flips=int(max_flips),
                                          emit_unverified=bool(emit_unverified))
              self.log_path = log_path
              self.c2_path = c2_path
              # optional time stamp on the hex port: none | utc | local | unix | stream
              self.hex_time = str(hex_time).strip().lower() or 'none'
              if self.hex_time not in ('none', 'utc', 'local', 'unix', 'stream'):
                  raise ValueError('hex_time must be one of none, utc, local, unix, stream (got %r)' % (hex_time,))
              self.fs_in = float(samp_rate)
              self.lookahead = float(delay_s)       # the tracker delays the stream by this many seconds
              self.n_in = 0                         # samples received so far (includes the silent pre-fill)
              self.rec_start = None
              if str(rec_start).strip():
                  import datetime
                  dt = datetime.datetime.fromisoformat(str(rec_start).strip().replace('Z', '+00:00'))
                  if dt.tzinfo is None:
                      dt = dt.replace(tzinfo=datetime.timezone.utc)      # a bare time is taken as UTC
                  self.rec_start = dt.timestamp()
              self.dll = None
              self.writer = None
              if dll_path:
                  try:
                      self.dll = DllDecoder(dll_path)
                      print('[hadesx] using official decoder from %s' % dll_path, flush=True)
                  except Exception as e:                      # noqa
                      print('[hadesx] could not load %s (%s) - install "unicorn pefile" for full '
                            'decoding; showing raw fields' % (dll_path, e), flush=True)

              if out_dir:           # per-type folder like AMSAT-EA's Windows tool (see docs/output-folder.md)
                  self.writer = FolderWriter(str(out_dir), utc=True, history=bool(out_history),
                                             fallback=lambda fr: format_frame(fr, self.dll))
                  print('[hadesx] updating the per-type folder %s' % out_dir, flush=True)

          def _epoch(self):
              """Reception time of the frames found in this call (epoch seconds, UTC)."""
              stream_t = self.n_in / self.fs_in - self.lookahead
              if self.rec_start is not None:
                  return self.rec_start + max(stream_t, 0.0)
              return time.time() - self.lookahead

          def _stamp(self):
              """Time stamp for the frames found in this call: the moment they were completed (about +-0.5 s)."""
              if self.hex_time == 'none':
                  return ''
              stream_t = self.n_in / self.fs_in - self.lookahead       # seconds into the input stream
              if self.hex_time == 'stream':
                  return '%.3f' % max(stream_t, 0.0)
              if self.rec_start is not None:
                  epoch = self.rec_start + stream_t                     # recording start + position in the file
              else:
                  epoch = time.time() - self.lookahead                  # live: samples are delayed by the look-ahead
              if self.hex_time == 'unix':
                  return '%.3f' % epoch
              import datetime
              dt = datetime.datetime.fromtimestamp(epoch, datetime.timezone.utc)
              if self.hex_time == 'local':
                  dt = dt.astimezone()
              stamp = dt.isoformat(timespec='milliseconds')
              # 'Z' only for utc; local keeps a numeric offset (even in a UTC zone) so it parses the same everywhere
              return stamp.replace('+00:00', 'Z') if self.hex_time == 'utc' else stamp

          def work(self, input_items, output_items):
              x = input_items[0]
              self.n_in += len(x)
              dd, frames = self.df.push(x)
              output_items[0][:len(dd)] = dd
              for fr in frames:
                  print(format_frame(fr, self.dll) + '\n', flush=True)
                  plain = bytes.fromhex(fr['plain'])
                  meta = pmt.to_pmt({'type': fr['type'], 'src': fr['src'],
                                     'sclock': fr['sclock'] if fr['sclock'] is not None else -1})
                  self.message_port_pub(pmt.intern('frames'),
                                        pmt.cons(meta, pmt.init_u8vector(len(plain), list(plain))))
                  # hex port: the PDU payload bytes as one lower-case hex string, optionally '<time stamp> <hex>'
                  stamp = self._stamp()
                  self.message_port_pub(pmt.intern('hex'),
                                        pmt.intern(stamp + ' ' + fr['plain'] if stamp else fr['plain']))
                  if self.writer is not None:
                      self.writer.write(fr, self._epoch())
                  if self.c2_path and fr.get('voice'):
                      with open(self.c2_path, 'ab') as f:
                          f.write(plain)
                  if self.log_path:
                      import json
                      with open(self.log_path, 'a') as f:
                          f.write(json.dumps(fr) + '\n')
              return len(x)
    bauds: bauds
    emit_unverified: emit_unverified
    out_dir: out_dir
    out_history: out_history
    comment: FSK discriminator / tone detector, clock recovery, sync 0xBF35, descramble, CRC16, decode. Frames are printed to the console.
    dll_path: dll_path
    log_path: log_path
    c2_path: c2_path
    delay_s: lookahead_s
    hex_time: hex_time
    max_flips: '3'
    rec_start: rec_start
    samp_rate: samp_rate / decim
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    comment: 'Raw IQ spectrum (whole 50 kHz band): the FSK signal can sit anywhere'
    fc: '0'
    fftsize: '2048'
    grid: 'True'
    gui_hint: 0,0,1,2
    name: '"Input spectrum (raw)"'
    type: complex
    ymax: '-20'
    ymin: '-120'
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate / decim
    color1: '"red"'
    comment: 'After the tracker: the two FSK tones should sit symmetrically about 0 Hz'
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: 1,0,1,1
    name: '"Centred signal"'
    type: complex
    ymax: '-20'
    ymin: '-120'
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    comment: 50000 -> 10 points per second
    n: '5000'
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    color1: green
    comment: Tracked FSK centre (Hz) over the last 60 s of input - you never have to tune
    grid: 'True'
    gui_hint: 2,0,1,2
    label1: centre (Hz)
    name: '"Tracked FSK centre"'
    size: '600'
    srate: '10'
    type: float
    width1: '2'
    ymax: '25000'
    ymin: '-25000'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    comment: Demodulated FSK (high = space/0, low = mark/1)
    grid: 'True'
    gui_hint: 1,1,1,1
    label1: demod
    name: '"FSK demod"'
    size: '2000'
    srate: samp_rate / decim
    type: float
    ymax: '2500'
    ymin: '-2500'
  states: {}

connections:
- [epy_block_src, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', epy_block_afc, '0']
- [epy_block_afc, '0', fir_filter_xxx_0, '0']
- [fir_filter_xxx_0, '0', epy_block_dec, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [fir_filter_xxx_0, '0', qtgui_freq_sink_x_1, '0']
- [epy_block_afc, '1', blocks_keep_one_in_n_0, '0']
- [blocks_keep_one_in_n_0, '0', qtgui_time_sink_x_1, '0']
- [epy_block_dec, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
