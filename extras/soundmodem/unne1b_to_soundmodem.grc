options:
  parameters:
    comment: Plays unne1b_fsk200_11025.wav into a virtual audio sink so that Wine soundmodem can record it. Start with PULSE_SINK=unne1b (see setup_unne1b_audio.sh).
    generate_options: qt_gui
    id: unne1b_to_soundmodem
    output_language: python
    title: UNNE-1B FSK 200 bd to soundmodem
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    comment: Must match the WAV (11025) and RXSampleRate in soundmodem.ini
    value: '11025'
  states: {}
- name: wav_path
  id: variable
  parameters:
    comment: Path to the WAV (relative to the directory you run from, or absolute)
    value: '''unne1b_fsk200_11025.wav'''
  states: {}
- name: audio_device
  id: variable
  parameters:
    comment: '"pulse" goes through the ALSA pulse plugin and honours PULSE_SINK'
    value: '''pulse'''
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    comment: Keep the audio level moderate; soundmodem does not like clipping
    label: Output gain
    start: '0'
    step: '0.01'
    stop: '1.0'
    value: '0.5'
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    comment: Repeats so soundmodem sees the burst over and over
    file: wav_path
    repeat: 'True'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: gain
    type: float
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: audio_device
    samp_rate: samp_rate
  states: {}

connections:
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_wavfile_source_0, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
